options:
  parameters:
    id: js_spike_probe_flowgraph
    title: JS Block spike probe
  states: {}

blocks:
- name: src
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: '320000'
    waveform: analog.GR_COS_WAVE
    frequency: '1000'
    amplitude: '1'
    offset: '0'
    phase: '0'
  states: {}
- name: probe
  id: js_spike_probe
  parameters:
    gain: '2'
  states: {}
- name: sink
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [src, '0', probe, '0']
- [probe, '0', sink, '0']

metadata:
  file_format: 1
