options:
  parameters:
    author: Marc
    description: Decodes the CHU shortwave time code from a 14670 kHz recording.
    generate_options: qt_gui
    id: CHU_Time_Signal_Decoder
    title: CHU Time Signal Decoder
  states: {}

blocks:
- name: channel_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: mark_tone
  id: variable
  parameters:
    value: '2225'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: space_tone
  id: variable
  parameters:
    value: '2025'
  states: {}
- name: chu_decoder
  id: ham_chu_decode
  parameters: {}
  states: {}
- name: complex17
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: discriminator
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate/(math.pi*(mark_tone - space_tone))
  states: {}
- name: intro
  id: note
  parameters:
    note: 300 baud AFSK on the Bell 103 tones; burst arrives 21 s in
  states: {}
- name: slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: source16
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: ham_chu_14670kHz
    repeat: 'True'
    type: short
  states: {}
- name: symbols
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: Discriminator
    name: FSK discriminator
    srate: channel_rate
    size: '4800'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
    yunit: ''
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: tone_channel
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (mark_tone + space_tone)/2
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 250, 500)
    type: ccf
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: 14670000 + (mark_tone + space_tone)/2
    fftsize: '1024'
    int_min: '-110'
    name: CHU tone channel
    bw: channel_rate
    update_time: '0.1'
  states: {}

connections:
- [complex17, '0', throttle, '0']
- [discriminator, '0', slicer, '0']
- [discriminator, '0', symbols, '0']
- [slicer, '0', chu_decoder, '0']
- [source16, '0', complex17, '0']
- [throttle, '0', tone_channel, '0']
- [tone_channel, '0', discriminator, '0']
- [tone_channel, '0', waterfall, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
