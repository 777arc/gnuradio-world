options:
  parameters:
    author: Marc
    description: Decodes a PSK31 QSO from a 40 m recording of 7071 kHz.
    generate_options: qt_gui
    id: PSK31_Receiver
    title: PSK31 Receiver
  states: {}

blocks:
- name: psk_offset
  id: variable
  parameters:
    value: '132'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '0.001'
    reference: '0.1'
    type: complex
  states: {}
- name: band_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: '7071000'
    fftsize: '2048'
    int_max: '0'
    int_min: '-120'
    name: 7071 kHz PSK31 watering hole
    bw: samp_rate
    update_time: '0.1'
  states: {}
- name: carrier
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 5*math.pi/100
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: Recovered symbols
    size: '512'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: differential
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: intro
  id: note
  parameters:
    note: KC3FL (Florida) working XE2BVM (Mexico), 31.25 baud BPSK
  states: {}
- name: real_part
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: source19
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: ham_psk31_7071kHz
    repeat: 'False'
    type: complex
  states: {}
- name: text
  id: wasm_text_sink
  parameters:
    max_line: '72'
    prefix: '"PSK31: "'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: timing
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: symbol_rate/31.25
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: tune
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: psk_offset
    decim: '16'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100, 100)
    type: ccf
  states: {}
- name: varicode
  id: ham_varicode_rx
  parameters: {}
  states: {}

connections:
- [agc, '0', carrier, '0']
- [carrier, '0', timing, '0']
- [differential, '0', real_part, '0']
- [real_part, '0', slicer, '0']
- [slicer, '0', varicode, '0']
- [source19, '0', throttle, '0']
- [throttle, '0', band_waterfall, '0']
- [throttle, '0', tune, '0']
- [timing, '0', constellation, '0']
- [timing, '0', differential, '0']
- [tune, '0', agc, '0']
- [varicode, '0', text, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
