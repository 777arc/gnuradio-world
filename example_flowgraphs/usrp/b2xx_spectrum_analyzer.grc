options:
  parameters:
    author: Marc
    description: |-
      Receive and display spectrum from a USRP B2xx over WebUSB.
      Runs with no hardware: Device is set to the test generator fake:100000. To use a real USRP, open the USRP B2xx Source and pick a device. On a board that has not been used since it was powered on you will be asked twice, because it changes USB identity when its firmware loads, and the first run after that loads the FPGA image, which takes a few minutes.
    generate_options: qt_gui
    id: USRP_B2xx_Receive_Example
    title: USRP B2xx Receive Example
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: '70000000'
    step: '1000000'
    stop: '6000000000'
    value: '100000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    min_len: '160'
    start: '0'
    step: '1'
    stop: '76'
    value: '30'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["1 MHz", "2 MHz", "4 MHz", "5 MHz", "8 MHz", "10 MHz", "15.36 MHz", "20 MHz"]'
    options: '[1000000, 2000000, 4000000, 5000000, 8000000, 10000000, 15360000, 20000000]'
    value: '1000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"center_freq":[0,0,4,1],"gain":[4,0,4,1],"samp_rate":[8,0,4,1],"qtgui_freq_sink_x_0":[0,1,12,3],"qtgui_waterfall_sink_x_0":[0,4,12,6]}'
    row_height: '60'
  states: {}
- name: wasm_usrp_b2xx_source_0
  id: wasm_usrp_b2xx_source
  parameters:
    antenna: RX2
    bandwidth: '0'
    center_freq: center_freq
    device: fake:100000
    gain: gain
    master_clock_rate: '0'
    samp_rate: samp_rate
  states: {}

connections:
- [wasm_usrp_b2xx_source_0, '0', qtgui_freq_sink_x_0, '0']
- [wasm_usrp_b2xx_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
