options:
  parameters:
    author: Marc
    description: Receive and display spectrum from a HackRF One over WebUSB.
    generate_options: qt_gui
    id: HackRF_Receive_Example
    title: HackRF Receive Example
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: '1000000'
    step: '1000000'
    stop: '6000000000'
    value: '100000000'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    label: RX IF Gain
    min_len: '160'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: RX Baseband Gain
    min_len: '180'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '16'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["2 MHz", "2.5 MHz", "4 MHz", "5 MHz", "8 MHz", "10 MHz", "12.5 MHz", "16 MHz", "20 MHz"]'
    options: '[2000000, 2500000, 4000000, 5000000, 8000000, 10000000, 12500000, 16000000, 20000000]'
    value: '10000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    average: '0.1'
    fc: center_freq
    fftsize: '2048'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    samp_rate: samp_rate
    update_time: '0.1'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"center_freq":[0,0,4,1],"lna_gain":[4,0,2,1],"vga_gain":[6,0,3,1],"samp_rate":[9,0,3,1],"qtgui_freq_sink_x_0":[0,1,12,3],"qtgui_waterfall_sink_x_0":[0,4,12,6]}'
    row_height: '60'
  states: {}
- name: wasm_hackrf_source_0
  id: wasm_hackrf_source
  parameters:
    amp: 'False'
    bandwidth: '0'
    bias_tee: 'False'
    center_freq: center_freq
    device: ''
    lna_gain: lna_gain
    samp_rate: samp_rate
    transfer_size: '262144'
    vga_gain: vga_gain
  states: {}

connections:
- [wasm_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [wasm_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
