options:
  parameters:
    author: GNU Radio World
    description: Filter out an interferer, decimate what is left, and tell the display about the new sample rate.
    generate_options: qt_gui
    id: Challenge_3
    title: Challenge 3
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analyzer
  id: wasm_spectrum_analyzer_sink
  parameters:
    average: '0.2'
    center_freq: '0'
    comment: Finds and measures signals
    db_per_div: '10'
    fftsize: '4096'
    level_offset_db: '0'
    level_unit: dBFS
    name: After the filter
    reference_level: '0'
    samp_rate: samp_rate
    trace_mode: average
    type: complex
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: challenge_3
  id: wasm_challenge
  parameters:
    challenge_id: challenge_3
    criteria: |-
      [
       {"kind": "param", "block": "lpf", "param": "cutoff_freq", "min": 60000, "max": 100000, "goal": "Set the Low Pass Filter cutoff to keep the 50 kHz tone and drop the 300 kHz interferer"},
       {"kind": "param", "block": "lpf", "param": "decim", "equals": 4, "goal": "Decimate by 4 in that same block -- 1 MHz of samples for a narrow signal is waste"},
       {"kind": "param", "block": "analyzer", "param": "samp_rate", "equals": 250000, "goal": "Tell the Spectrum Analyzer its input rate is now samp_rate/4"},
       {"kind": "detected_signal", "center_freq": 50000, "center_tol": 15000, "min_peak_level": -40, "goal": "Run it: the tone still reads 50 kHz, and the interferer is gone"}
      ]
    requires: challenge_2
    title: Filter and decimate
  states: {}
- name: channel
  id: blocks_add_xx
  parameters:
    comment: What the radio hears
    num_inputs: '3'
    type: complex
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"analyzer":[0,0,12,8]}'
    row_height: '60'
  states: {}
- name: interferer
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: The one you do not want
    freq: '300000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: lpf
  id: low_pass_filter
  parameters:
    comment: |-
      Passes low frequencies,
      stops high ones
    cutoff_freq: '400000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: 'Two tones arrive together: the one you want at 50 kHz, and an interferer at 300 kHz. A low-pass filter passes everything below its cutoff frequency and attenuates everything above it, over a transition band whose width you also choose. The cutoff is wide open at 400 kHz right now, so both get through.'
  states: {}
- name: note_1
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: |-
      Once a signal is narrow, carrying it at 1 MS/s is wasted work. Decimating by 4 keeps every 4th sample, and the stream leaving the filter is 250 kS/s. That is why you filter first: anything left above the new Nyquist rate of 125 kHz would fold back on top of your signal.

      A block that changes the sample rate does not tell the blocks after it. They take their rate as a parameter, and it is on you to keep it right.
  states: {}
- name: note_2
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: |-
      Challenge:
      1) Run it first and see both tones
      2) Set the Low Pass Filter cutoff between the two -- well above 50 kHz, well below both 300 kHz and the 125 kHz Nyquist rate you are about to create
      3) Set its Decimation to 4
      4) Set the Spectrum Analyzer's Sample Rate to samp_rate/4, or the display will put the tone at the wrong frequency
      5) Run it again: one tone, still at 50 kHz, in a span four times narrower
  states: {}
- name: receiver_noise
  id: analog_noise_source_x
  parameters:
    amp: '0.002'
    comment: Gives the detector a noise floor
    noise_type: analog.GR_GAUSSIAN
    seed: '7'
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    comment: |-
      Limits the rate of IQ samples
      flowing through
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wanted
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: The one you want
    freq: '50000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [channel, '0', throttle, '0']
- [interferer, '0', channel, '1']
- [lpf, '0', analyzer, '0']
- [receiver_noise, '0', channel, '2']
- [throttle, '0', lpf, '0']
- [wanted, '0', channel, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
