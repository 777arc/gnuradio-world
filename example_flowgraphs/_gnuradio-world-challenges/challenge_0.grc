options:
  parameters:
    author: Marc
    generate_options: qt_gui
    id: Challenge_0
    title: Challenge 0
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Creates a tone
    freq: '70'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Limits the rate of IQ samples
      flowing through
    samples_per_second: samp_rate
    type: float
  states: {}
- name: challenge_0
  id: wasm_challenge
  parameters:
    challenge_id: challenge_0
    criteria: |-
      [
       {"kind": "ran", "seconds": 2, "goal": "Run the flowgraph and watch the scope"},
       {"kind": "param", "block": "analog_sig_source_x_0", "param": "freq", "equals": 200, "goal": "Set the Signal Source frequency to 200 Hz"}
      ]
    requires: ''
    title: Change the tone
  states: {}
- name: note_0
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: In this starter flowgraph, real-valued samples are generated by the Signal Source, it creates a tone at 70 Hz.
  states: {}
- name: note_0_0
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: Because there is no hardware/SDR/audio blocks, the Signal Source would generate samples as fast as it can (it doesn't limit itself to samp_rate), so we add a Throttle block to limit the flow of samples.
  states: {}
- name: note_0_1
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: |-
      Challenge:
      1) Run the flowgraph using the play button at the top, observe what happens, then stop it with the stop button
      2) Change the frequency of the tone to 200 Hz
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    comment: Displays the time domain
    name: Scope
    size: '2000'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
