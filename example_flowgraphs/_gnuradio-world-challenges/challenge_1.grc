options:
  parameters:
    author: GNU Radio World
    description: Tune a tone to a target frequency and confirm it on the spectrum analyzer.
    generate_options: qt_gui
    id: Challenge_1
    title: Challenge 1
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tone_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analyzer
  id: wasm_spectrum_analyzer_sink
  parameters:
    average: '0.2'
    center_freq: center_freq
    comment: Finds and measures signals
    db_per_div: '10'
    fftsize: '4096'
    level_offset_db: '0'
    level_unit: dBFS
    name: Tune the tone
    reference_level: '0'
    samp_rate: samp_rate
    trace_mode: average
    type: complex
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: challenge_1
  id: wasm_challenge
  parameters:
    challenge_id: challenge_1
    criteria: |-
      [
       {"kind": "ran", "seconds": 3, "goal": "Run the flowgraph and find the tone on the spectrum"},
       {"kind": "detected_signal", "center_freq": 100250000, "center_tol": 20000, "min_peak_level": -40, "goal": "Move the tone to 100.25 MHz - 250 kHz above the center frequency"}
      ]
    requires: challenge_0
    title: Tune the tone
  states: {}
- name: channel_sum
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: channel_throttle
  id: blocks_throttle2
  parameters:
    comment: |-
      Limits the rate of IQ samples
      flowing through
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"analyzer":[0,0,12,8]}'
    row_height: '60'
  states: {}
- name: note_0
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: The radio is tuned to 100 MHz and listening across 1 MHz of spectrum, so the analyzer shows 99.5 MHz to 100.5 MHz. The Signal Source adds a tone at an offset from that center frequency.
  states: {}
- name: note_1
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: |-
      Challenge:
      1) Run the flowgraph and find the tone -- it starts at the center of the display
      2) Put the tone at 100.25 MHz by changing the tone_offset variable

      The offset is relative to the center frequency, and a variable is edited the same way a block parameter is: double-click it.
  states: {}
- name: receiver_noise
  id: analog_noise_source_x
  parameters:
    amp: '0.002'
    comment: Gives the detector a noise floor
    noise_type: analog.GR_GAUSSIAN
    seed: '7'
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: The tone you are moving
    freq: tone_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [channel_sum, '0', channel_throttle, '0']
- [channel_throttle, '0', analyzer, '0']
- [receiver_noise, '0', channel_sum, '1']
- [tone, '0', channel_sum, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
