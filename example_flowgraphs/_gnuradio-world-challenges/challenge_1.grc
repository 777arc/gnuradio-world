options:
  parameters:
    author: Marc
    description: Add a Frequency Sink of your own, then look at a square wave in the frequency domain.
    generate_options: qt_gui
    id: Challenge_1
    title: Challenge 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: challenge_1
  id: wasm_challenge
  parameters:
    challenge_id: challenge_1
    criteria: |-
      [
       {"kind": "block_present", "id": "qtgui_freq_sink_x", "goal": "Add a QT GUI Frequency Sink and connect the Throttle to it"},
       {"kind": "ran", "seconds": 4, "goal": "Run it: one cosine is one spike in the frequency domain"},
       {"kind": "param", "block": "tone", "param": "waveform", "matches": "SQR", "goal": "Switch the Signal Source to a square wave and find its harmonics"}
      ]
    requires: challenge_0
    title: Into the frequency domain
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"time_sink":[0,0,12,5]}'
    row_height: '60'
  states: {}
- name: note_0
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: 'A Time Sink shows a signal as amplitude against time. The other half of DSP is the frequency domain: the same samples, drawn as how much energy sits at each frequency. GNU Radio has a sink for that too -- the QT GUI Frequency Sink.'
  states: {}
- name: note_1
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: |-
      Challenge:
      1) Find "QT GUI Frequency Sink" in the block palette on the left and drag it onto the canvas.
      2) Set its Type to Float (note the Down button is a shortcut). Our samples are real, not complex, and a Complex input port will refuse to connect to a Float stream.
      3) Connect the Throttle's output to it: click the output port, then the sink's input port. A stream can feed more than one sink
      4) Run it. The 1 kHz cosine is a single spike
      5) Stop, then change the Signal Source waveform to Square. A square wave is a sum of odd harmonics: spikes at 3 kHz, 5 kHz, 7 kHz ... each smaller than the last
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    comment: |-
      Limits the rate of samples
      flowing through
    samples_per_second: samp_rate
    type: float
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    comment: The time domain
    name: Time domain
    size: '512'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    yunit: ''
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: A 1 kHz tone
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}

connections:
- [throttle, '0', time_sink, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
