options:
  parameters:
    author: GNU Radio World
    description: Wire a slider to a block parameter, then tune the tone to 100.25 MHz while the flowgraph runs.
    generate_options: qt_gui
    id: Challenge_2
    title: Challenge 2
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tone_offset
  id: variable_qtgui_range
  parameters:
    label: Tone offset from center (Hz)
    min_len: '300'
    start: '-400000'
    step: '1000'
    stop: '400000'
    value: '0'
  states: {}
- name: analyzer
  id: wasm_spectrum_analyzer_sink
  parameters:
    average: '0.2'
    center_freq: center_freq
    comment: Finds and measures signals
    db_per_div: '10'
    fftsize: '4096'
    level_offset_db: '0'
    level_unit: dBFS
    name: Tune the tone
    reference_level: '0'
    samp_rate: samp_rate
    trace_mode: average
    type: complex
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: challenge_2
  id: wasm_challenge
  parameters:
    challenge_id: challenge_2
    criteria: |-
      [
       {"kind": "param", "block": "tone", "param": "freq", "matches": "^\\s*tone_offset\\s*$", "goal": "Set the Signal Source's Frequency to tone_offset, so the slider drives it"},
       {"kind": "ran", "seconds": 3, "goal": "Run it: the slider appears above the spectrum"},
       {"kind": "detected_signal", "center_freq": 100250000, "center_tol": 20000, "min_peak_level": -40, "goal": "Without stopping, tune the tone to 100.25 MHz -- 250 kHz above center"}
      ]
    requires: challenge_1
    title: Turn the knob
  states: {}
- name: channel
  id: blocks_add_xx
  parameters:
    comment: What the radio hears
    type: complex
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"analyzer":[0,1,12,7],"tone_offset":[0,0,12,1]}'
    row_height: '60'
  states: {}
- name: note_0
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: 'The radio is tuned to 100 MHz and listening across 1 MHz of spectrum, so the analyzer shows 99.5 MHz to 100.5 MHz. The Signal Source''s frequency is an offset from that center: 0 puts the tone right in the middle.'
  states: {}
- name: note_1
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: 'A block parameter does not have to be a number -- it can be the name of a variable. tone_offset is a QT GUI Range: a variable with a slider attached, which can be moved while the flowgraph is running. Parameters that accept a new value at run time are underlined in the properties dialog.'
  states: {}
- name: note_2
  id: note
  parameters:
    bgcolor: '#4dff6a'
    note: |-
      Challenge:
      1) Double-click the Signal Source and set its Frequency to tone_offset (type the name, not a number)
      2) Run it. The slider appears above the spectrum
      3) Drag the slider -- or type into its box -- until the tone sits at 100.25 MHz. The analyzer labels every signal it finds with its measured center frequency, so read it off the plot
  states: {}
- name: receiver_noise
  id: analog_noise_source_x
  parameters:
    amp: '0.002'
    comment: Gives the detector a noise floor
    noise_type: analog.GR_GAUSSIAN
    seed: '7'
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    comment: |-
      Limits the rate of IQ samples
      flowing through
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: The tone you are tuning
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [channel, '0', throttle, '0']
- [receiver_noise, '0', channel, '1']
- [throttle, '0', analyzer, '0']
- [tone, '0', channel, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
