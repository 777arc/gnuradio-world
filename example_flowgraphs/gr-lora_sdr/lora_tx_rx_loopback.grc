options:
  parameters:
    author: Tapparel Joachim
    description: 'A complete LoRa link in one tab: gr-lora_sdr''s transmitter feeds its receiver through a noisy channel, and each decoded payload is printed below. Adapted from the module''s own tx_rx_hier_functionality_check.'
    generate_options: qt_gui
    id: LoRa_Tx___Rx_loopback
    title: LoRa Tx + Rx loopback
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    comment: Channel SNR
    value: '10'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw*4
  states: {}
- name: sf
  id: variable
  parameters:
    comment: Spreading factor
    value: '7'
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: 10**(-SNRdB/20)
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: lora_rx
  id: lora_rx
  parameters:
    bw: bw
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: sf
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx
  id: lora_tx
  parameters:
    bw: bw
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: sf
    sync_word: '[0x12]'
  states: {}
- name: next_id
  id: lora_sdr_payload_id_inc
  parameters:
    comment: |-
      Increments the counter after the
      separator so every frame differs
    separator: ':'
  states: {}
- name: payload
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.intern("Hello GNU Radio World: 0")'
    period: '1500'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    name: Scope
    samp_rate: samp_rate
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: received
  id: wasm_text_sink
  parameters:
    max_line: '72'
    prefix: '"LoRa RX: "'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"qtgui_time_sink_x_0":[0,0,12,4]}'
    row_height: '60'
  states: {}

connections:
- [channel, '0', lora_rx, '0']
- [channel, '0', qtgui_time_sink_x_0, '0']
- [lora_rx, '0', received, '0']
- {src_blk_id: lora_rx, src_port_id: out, snk_blk_id: frames, snk_port_id: print}
- [lora_tx, '0', throttle, '0']
- {src_blk_id: next_id, src_port_id: msg_out, snk_blk_id: payload, snk_port_id: set_msg}
- {src_blk_id: payload, src_port_id: strobe, snk_blk_id: lora_tx, snk_port_id: in}
- {src_blk_id: payload, src_port_id: strobe, snk_blk_id: next_id, snk_port_id: msg_in}
- [throttle, '0', channel, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
