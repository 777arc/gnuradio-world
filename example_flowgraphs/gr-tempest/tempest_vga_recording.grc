options:
  parameters:
    author: Marc
    description: Recovers the picture on a VGA monitor from a recording of the emissions its cable leaks (TEMPEST), using gr-tempest. The screen was 1024x768 @ 60 Hz, sampled at 30 MS/s by a USRP B200; only 620 of every 1344-pixel line fit in that bandwidth, so the recovered frame is 620 samples wide. Fine Sampling Synchronization locks to the line and frame periods, the two Delays pan the frame, Normalize Flow maps magnitude to 0..255 luma, and Framing crops the vertical blanking before the Video Sink paints it.
    generate_options: qt_gui
    id: TEMPEST_from_a_VGA_Recording
    title: TEMPEST from a VGA Recording
  states: {}

blocks:
- name: Hdisplay
  id: variable
  parameters:
    comment: Visible pixels per line on the spied screen
    value: '1024'
  states: {}
- name: Hsize
  id: variable
  parameters:
    comment: Total pixels per line, blanking included (1024x768@60 is 1344x806)
    value: '1344'
  states: {}
- name: Vdisplay
  id: variable
  parameters:
    comment: Visible lines on the spied screen
    value: '768'
  states: {}
- name: Vsize
  id: variable
  parameters:
    comment: Total lines per frame, blanking included
    value: '806'
  states: {}
- name: horizontal_offset
  id: variable_qtgui_range
  parameters:
    comment: Pans the frame sideways, one sample per step
    label: Horizontal offset (samples)
    rangeType: int
    start: '0'
    step: '1'
    stop: '619'
    value: '460'
  states: {}
- name: interpolatedHsize
  id: variable
  parameters:
    comment: Samples per line at this sample rate, 620 here
    value: int(Hsize/float(px_rate)*samp_rate)
  states: {}
- name: px_rate
  id: variable
  parameters:
    comment: The monitor's pixel clock
    value: Hsize*Vsize*refresh_rate
  states: {}
- name: refresh_rate
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: The recording's own sample rate
    value: int(30e6)
  states: {}
- name: vertical_offset
  id: variable_qtgui_range
  parameters:
    comment: Pans the frame up and down; each step is one 620-sample line
    label: Vertical offset (samples, 620 per line)
    rangeType: int
    start: '0'
    step: '620'
    stop: '499720'
    value: '467480'
  states: {}
- name: framing
  id: tempest_framing
  parameters:
    Hdisplay: interpolatedHsize
    Htotal: interpolatedHsize
    Vdisplay: Vdisplay
    Vtotal: Vsize
    comment: Drops the vertical blanking lines; the line already fits, so Hdisplay = Htotal
  states: {}
- name: line_sync
  id: tempest_fine_sampling_synchronization
  parameters:
    Htotal: interpolatedHsize
    Vtotal: Vsize
    comment: Resamples so every line is exactly Htotal samples and every frame Vtotal lines
    correct_sampling: '1'
    max_deviation: 10.0/interpolatedHsize
    update_proba: 1e-2/(Hsize*Vsize)
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: normalize
  id: tempest_normalize_flow
  parameters:
    alpha_avg: '0.01'
    comment: Tracks the running min and max and maps them to 10..245
    max: '245'
    min: '10'
    update_proba: '0.1'
    window: interpolatedHsize
  states: {}
- name: pan_h
  id: blocks_delay
  parameters:
    delay: horizontal_offset
    type: complex
  states: {}
- name: pan_v
  id: blocks_delay
  parameters:
    delay: vertical_offset
    type: complex
  states: {}
- name: rec
  id: wasm_gr_world_recording
  parameters:
    comment: The gr-tempest authors' recording4, a VGA cable at 1024x768; Length is 120 whole frames of 499751 samples so the loop is seamless
    length: '59970120'
    offset: '0'
    progress: 'True'
    recording: tempest/vga_1024x768_60Hz_30MSps
    repeat: 'True'
    type: short
  states: {}
- name: screen
  id: wasm_video_sink
  parameters:
    comment: 620 samples span each 1344-pixel line, so the picture is shown at the screen's aspect ratio
    display_height: Vdisplay
    display_width: Hdisplay
    height: Vdisplay
    name: '"Recovered screen"'
    type: float
    width: interpolatedHsize
  states: {}
- name: to_complex
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32000'
    vector_input: 'False'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"horizontal_offset":[0,0,6,1],"vertical_offset":[6,0,6,1],"rec":[0,1,12,1],"screen":[0,2,12,10]}'
    row_height: '60'
  states: {}

connections:
- [framing, '0', screen, '0']
- [line_sync, '0', pan_v, '0']
- [mag, '0', normalize, '0']
- [normalize, '0', framing, '0']
- [pan_h, '0', mag, '0']
- [pan_v, '0', pan_h, '0']
- [rec, '0', to_complex, '0']
- [to_complex, '0', line_sync, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
