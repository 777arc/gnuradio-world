options:
  parameters:
    author: Marc
    description: OFDM tx and rx with packet rate counter
    generate_options: qt_gui
    id: OFDM_Loopback_and_Bit_Error_Counter
    title: OFDM Loopback and Bit Error Counter
  states: {}

blocks:
- name: noise_amplitude
  id: variable_qtgui_range
  parameters:
    label: Noise amplitude
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: bit_error_display
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: '"Bit errors in latest packet"'
    max: '768'
    min: '0'
    name: '"OFDM Bit Errors"'
    type: float
    unit1: '" bits"'
    update_time: '0.1'
  states: {}
- name: byte_errors
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: channel_noise
  id: analog_noise_source_x
  parameters:
    amplitude: noise_amplitude
    seed: '0'
    type: complex
  states: {}
- name: error_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: error_inject
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: error_pattern
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 4, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
  states: {}
- name: errors_as_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: errors_per_packet
  id: blocks_integrate_xx
  parameters:
    decim: '768'
    type: float
  states: {}
- name: packet_rate_display
  id: wasm_packet_rate_sink
  parameters:
    items_per_packet: '96'
    label: '"Packets decoded"'
    name: '"OFDM Link Rate"'
    type: byte
    unit: '" pkt/s"'
    update_time: '0.5'
  states: {}
- name: packet_tagger
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length
    packet_len: '96'
    type: byte
  states: {}
- name: payload
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95]'
  states: {}
- name: receiver
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    packet_len_key: '"length"'
    payload_mod: '"BPSK"'
  states: {}
- name: reference_payload
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95]'
  states: {}
- name: strip_tx_tags
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '192000'
    type: complex
  states: {}
- name: transmitter
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    packet_len_key: length
    payload_mod: '"BPSK"'
    rolloff: '0'
  states: {}
- name: x16
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    marker1: '0'
    name: Scope
    samp_rate: '32000'
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '20'
    ymin: '-20'
    yunit: ''
  states: {}

connections:
- [add_noise, '0', throttle, '0']
- [byte_errors, '0', error_bits, '0']
- [channel_noise, '0', add_noise, '1']
- [error_bits, '0', errors_as_float, '0']
- [error_inject, '0', byte_errors, '0']
- [error_pattern, '0', error_inject, '1']
- [errors_as_float, '0', errors_per_packet, '0']
- [errors_per_packet, '0', bit_error_display, '0']
- [packet_tagger, '0', transmitter, '0']
- [payload, '0', packet_tagger, '0']
- [receiver, '0', error_inject, '0']
- [receiver, '0', packet_rate_display, '0']
- [reference_payload, '0', byte_errors, '1']
- [strip_tx_tags, '0', receiver, '0']
- [strip_tx_tags, '0', x16, '0']
- [throttle, '0', strip_tx_tags, '0']
- [transmitter, '0', add_noise, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
