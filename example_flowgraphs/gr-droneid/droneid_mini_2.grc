options:
  parameters:
    author: Marc
    description: Detects DroneID frames in the public 50 MS/s DJI Mini 2 IQ artifact by correlating its root-600 Zadoff-Chu preamble. Message Debug counts the ten curated bursts in this file. In a continuous recording, successive "Found burst" sample offsets should be about 9,830,400 samples apart at 15.36 MS/s (roughly 640 ms); this shortened artifact does not preserve that cadence.
    generate_options: qt_gui
    id: DJI_DroneID_frame_detector___Mini_2_recording
    title: DJI DroneID frame detector — Mini 2 recording
  states: {}

blocks:
- name: capture_rate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: channel_offset
  id: variable
  parameters:
    value: '9619140.625'
  states: {}
- name: droneid_rate
  id: variable
  parameters:
    value: '15360000'
  states: {}
- name: padding_samples
  id: variable
  parameters:
    value: '30000'
  states: {}
- name: recording_samples
  id: variable
  parameters:
    value: '727500'
  states: {}
- name: align_frame_start
  id: blocks_delay
  parameters:
    delay: '6439'
    type: complex
  states: {}
- name: append_padding
  id: blocks_stream_mux
  parameters:
    lengths: '[recording_samples, padding_samples]'
    type: complex
  states: {}
- name: channel_shift
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-channel_offset'
    samp_rate: capture_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: correlation_power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: detect_frames
  id: droneid_extractor
  parameters:
    sample_rate: droneid_rate
    threshold: '0.15'
  states: {}
- name: detection_count
  id: satellites_message_counter
  parameters: {}
  states: {}
- name: mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: padding_head
  id: blocks_head
  parameters:
    num_items: padding_samples
    type: complex
  states: {}
- name: preamble_correlator
  id: droneid_normalized_xcorr_estimate
  parameters:
    taps: '[(0.0162593207+0.01621688017j),(-0.005267471372-0.004136698763j),(-0.01528831455-0.01622318648j),(0.01186122062+0.009111269675j),(0.00742134712+0.01093742012j),(-0.01797618582-0.01530754045j),(0.0002148935663-0.00647999096j),(0.01679010082+0.01645045511j),(-0.01091827432-0.00176727441j),(-0.01363319341-0.01765317051j),(0.01681547968+0.007234146267j),(0.003914948746+0.01340729557j),(-0.0215425626-0.01439357569j),(0.00496674816-0.009643829295j),(0.01856655485+0.01685224774j),(-0.01618443688+0.001594666831j),(-0.01354733166-0.01954742386j),(0.02189980538+0.004259491068j),(0.002183091449+0.0167576054j),(-0.02591674861-0.01240662815j),(0.007945969394-0.01418903045j),(0.02194209656+0.01638855687j),(-0.01996885704+0.006864954318j),(-0.01587075338-0.02100192961j),(0.02613370985-0.001100260417j),(0.003560344437+0.02032242003j),(-0.03041419475-0.007693680541j),(0.007370056176-0.01981270235j),(0.02669948572+0.01307901813j),(-0.02013740843+0.01423875096j),(-0.02100507491-0.0197865625j),(0.02717020851-0.009673797647j),(0.009191165523+0.02174429683j),(-0.03264906158+0.001331260221j),(0.001259905761-0.02419953472j),(0.03061765976+0.004482000386j),(-0.01382006336+0.02165759675j),(-0.02712366762-0.01254532629j),(0.021231637-0.01991358863j),(0.01789655711+0.01674702697j),(-0.0279650339+0.01391509195j),(-0.01012666959-0.02221122116j),(0.0282447916-0.009743356608j),(-6.551914986e-05+0.02325091505j),(-0.02812617195+0.002456267691j),(0.005865683688-0.02542187822j),(0.02314715201+0.001919847535j),(-0.01212828059+0.02341210137j),(-0.02012832429-0.008512086019j),(0.01331571759-0.02305084778j),(0.01470610775+0.01155884858j),(-0.01551786005+0.01917698223j),(-0.01318898513-0.01647711301j),(0.01409109334-0.01765057549j),(0.01029418305+0.01777156518j),(-0.01549286992+0.01324316043j),(-0.01129112483-0.02106654187j),(0.01488878933-0.0116834154j),(0.01002864187+0.02099717393j),(-0.01810401948+0.007585294753j),(-0.01129657041-0.02324071205j),(0.01945365527-0.006527673071j),(0.008947112268+0.02242111663j),(-0.02395643425+0.003006880806j),(-0.008211102935-0.02416240671j),(0.02539327416-0.002528432828j),(0.003657098898+0.02301762496j),(-0.0286558423-0.0004404524808j),(-0.001280736229-0.02454334708j),(0.02781625315+0.0003885661165j),(-0.003761343362+0.02324274105j),(-0.02836803177-0.002822896202j),(0.0052237098-0.02464550904j),(0.02510634216+0.002201819742j),(-0.00809535146+0.02324835284j),(-0.02415476247-0.004009766845j),(0.006614649217-0.02458665202j),(0.02066739482+0.002697568156j),(-0.006443041694+0.02316425737j),(-0.02076126733-0.003758389689j),(0.002484593647-0.02451536068j),(0.01923000274+0.001664505201j),(-0.0008752588842+0.02312786461j),(-0.02158557455-0.001936947222j),(-0.003319778699-0.02450351644j),(0.0219443548-0.0009241779179j),(0.004145262288+0.02308420991j),(-0.02525370487+0.001374442023j),(-0.006988916988-0.02431861002j),(0.0253236512-0.004895754876j),(0.006476183139+0.02259677524j),(-0.02712152088+0.005928424095j),(-0.008527116882-0.0233251352j),(0.0247790909-0.009936334897j),(0.008093516064+0.02086811808j),(-0.02378173058+0.01133246568j),(-0.01112007364-0.02062811294j),(0.01882296758-0.01553859422j),(0.01227232032+0.01699012974j),(-0.0158397276+0.01690847968j),(-0.01697522691-0.0154034344j),(0.009755994725-0.02078996524j),(0.01928169239+0.01032723867j),(-0.006480486829+0.02145611499j),(-0.02407515901-0.007313099072j),(0.0006942225517-0.02418076205j),(0.02508148078+0.0009507461148j),(0.002042323393+0.02318760142j),(-0.02715802367+0.003051297486j),(-0.007361584528-0.02374635447j),(0.02431618706-0.009925733552j),(0.009855002675+0.02014246589j),(-0.02194780734+0.01377835244j),(-0.01507233843-0.01779039699j),(0.01473328353-0.01966942028j),(0.01729386287+0.01121278224j),(-0.008735021115+0.02157674595j),(-0.02161819155-0.006150787959j),(-0.0008119648348-0.02451666126j),(0.02188519673-0.002476815714j),(0.007484052883+0.02255030384j),(-0.02293773354+0.00850435388j),(-0.01590714966-0.02094286208j),(0.01869325086-0.01662359554j),(0.01972903183+0.01419113108j),(-0.01448306326+0.02039726115j),(-0.0238255547-0.008173066834j),(0.005098086893-0.02445625559j),(0.02224316642-0.001878234728j),(0.003011292433+0.02259919068j),(-0.02039112234+0.009329935358j),(-0.01392619773-0.02004455463j),(0.01298284142-0.01832861445j),(0.0203515157+0.01152570697j),(-0.006218379202+0.02193826454j),(-0.02609207319-0.003453017362j),(-0.004325580571-0.0244947017j),(0.02434980177-0.008180574691j),(0.01163616624+0.01985877182j),(-0.02025329258+0.01591659941j),(-0.0195766687-0.01376645055j),(0.009004121221-0.02325157483j),(0.02107809858+0.001908770427j),(0.001964282352+0.02304820206j),(-0.02067638062+0.0080770643j),(-0.01539189639-0.02011277285j),(0.01279505847-0.01903359227j),(0.02266147659+0.009519426459j),(-0.004132989059+0.02283662938j),(-0.02674341945+0.001211044072j),(-0.008500642624-0.02323444859j),(0.02091743554-0.01448048554j),(0.01650201813+0.01448769654j),(-0.0115054088+0.02128722636j),(-0.02242466748-0.003814565093j),(-0.004162688518-0.02435118419j),(0.01888047174-0.01087117898j),(0.01622190034+0.01712301301j),(-0.01155500051+0.01975600929j),(-0.02565662449-0.006542837096j),(-0.002571901564-0.02458908751j),(0.02378658527-0.009111732782j),(0.01360882914+0.01812643146j),(-0.01580649201+0.01920143301j),(-0.02227755091-0.007227950064j),(-0.0007658106779-0.0246184847j),(0.01970911689-0.009245266254j),(0.01469406219+0.01772826019j),(-0.01127656426+0.01972935486j),(-0.02518606619-0.005759968915j),(-0.004910486391-0.02443475656j),(0.0224830369-0.01143137782j),(0.01693994391+0.01583169581j),(-0.0122304571+0.0212516311j),(-0.02386298311-0.002177004428j),(-0.006109363404-0.02362157633j),(0.01680600922-0.01521041295j),(0.01897185574+0.01194744334j),(-0.003330705673+0.02280409724j),(-0.02458119264+0.003604648187j),(-0.01495067401-0.0210387842j),(0.01484128462-0.01990066692j),(0.02344225769+0.005447695569j),(0.0005289735178+0.02308185002j),(-0.02160325628+0.01104641566j),(-0.01773933786-0.01551788239j),(0.004842494862-0.02374139622j),(0.02179778902-0.003698247346j),(0.0129522883+0.0199690089j),(-0.01451204044+0.01856168784j),(-0.02579035596-0.006061335927j),(-0.004570911653-0.02422195379j),(0.02049339251-0.01427181351j),(0.01841571757+0.01179366495j),(-0.004391681357+0.02307284635j),(-0.02182919963+0.006444774517j),(-0.0169220498-0.01846065555j),(0.007081794227-0.02270907372j),(0.02427774988-0.001564872008j),(0.01134055331+0.02055943865j),(-0.01671207616+0.01841961978j),(-0.02432299059-0.005406445817j),(-0.005058033899-0.02387362395j),(0.01672782004-0.01629739512j),(0.02010562606+0.008654919587j),(0.002206568259+0.02319328413j),(-0.02085972937+0.01140687537j),(-0.0224884369-0.01360292157j),(0.002004032384-0.02452282128j),(0.02294408661-0.009618162483j),(0.01634403647+0.01488173543j),(-0.006763008748+0.02266576581j),(-0.02222141041+0.005591812864j),(-0.01721724149-0.01807217522j),(0.005244489394-0.02342839413j),(0.02373231669-0.00504381799j),(0.01550401237+0.01783345592j),(-0.01096980119+0.02156620902j),(-0.02468451659+0.002456190625j),(-0.01353509298-0.01982348965j),(0.008223737578-0.02266289718j),(0.02186006318-0.003385598484j),(0.01480401016+0.01853600173j),(-0.009558343533+0.02131313449j),(-0.02597087665+0.002354833685j),(-0.01515084748-0.01956717697j),(0.009325897-0.02302566144j),(0.02188541508-0.004813877318j),(0.01426117612+0.01732001796j),(-0.006354494511+0.02216346301j),(-0.02382907617+0.005282383204j),(-0.0194741042-0.01720218694j),(0.004824881205-0.02415294212j),(0.02273715881-0.00920265753j),(0.01721962677+0.01360959902j),(-0.0026702528+0.02319743755j),(-0.02014971273+0.01092202202j),(-0.02231529073-0.01185566625j),(-0.004230025587-0.0245108554j),(0.01898449629-0.01580108148j),(0.02281168459+0.006349396995j),(0.0048283065+0.02222882705j),(-0.01558871879+0.01793008784j),(-0.02321846897-0.002596507286j),(-0.01354804267-0.02140790168j),(0.008619504938-0.02235646512j),(0.02422203961-0.004798462047j),(0.01640499203+0.01621400352j),(-0.006035725634+0.02293082776j),(-0.02157678726+0.009853016859j),(-0.02076462287-0.01194500247j),(-0.005203117159-0.02439014144j),(0.01603080378-0.01739735653j),(0.02432904949+0.00316353913j),(0.009990077748+0.02057049959j),(-0.01229962847+0.02088014235j),(-0.02318951261+0.004006549919j),(-0.01797630221-0.01652361071j),(-0.0003936746046-0.02456783133j),(0.01925222287-0.01400333274j),(0.0233373765+0.006826292728j),(0.006670052527+0.02184053986j),(-0.01423289506+0.0196410438j),(-0.02325167033+0.002066004765j),(-0.01749253081-0.01751583994j),(0.0003566817375-0.02450457242j),(0.01978114878-0.01387760281j),(0.02324033042+0.00639924463j),(0.00733768121+0.02146351119j),(-0.01239447789+0.0204650356j),(-0.02278790565+0.004295549417j),(-0.01983124079-0.01536075234j),(-0.002960402227-0.02460042068j),(0.01763295299-0.01707070021j),(0.02383744195+0.001829952239j),(0.01177695838+0.01894030687j),(-0.006471600018+0.0225549535j),(-0.02065266754+0.0103793428j),(-0.02369929362-0.009200508684j),(-0.01018382789-0.02303768211j),(0.01129373292-0.02202903552j),(0.02271513331-0.006987599464j),(0.01825976566+0.01211321962j),(0.003985685983+0.02286106293j),(-0.0139675699+0.01847206073j),(-0.02544633651+0.001918420923j),(-0.01944832155-0.01623274265j),(-0.0006887075816-0.02460347269j),(0.01561682891-0.01810014208j),(0.02207394219-0.0009104011171j),(0.016882683+0.01634453429j),(-0.000377480433+0.02324361033j),(-0.01923899508+0.01577372698j),(-0.02475324976-0.001466654821j),(-0.01580783879-0.01818856225j),(-0.0004567702926-0.02461599305j),(0.01573548834-0.01716655452j),(0.02427551113-0.0002920810823j),(0.01655129579+0.01630262747j),(-0.001617045049+0.02325426605j),(-0.01677227426+0.01678392434j),(-0.02352324274+0.0006586946554j),(-0.0198369883-0.01613719424j),(-0.004037690175-0.02447031157j),(0.01470948658-0.01995331254j),(0.02279631836-0.005151485188j),(0.01848478591+0.01195456416j),(0.006454656392+0.02235182775j),(-0.01056261593+0.02073902663j),(-0.0240414492+0.008106482561j),(-0.02336646602-0.008970444325j),(-0.0108074976-0.02179632558j),(0.004339735546-0.02399750513j),(0.01780746031-0.01463939136j),(0.02408868882+0.001521355833j),(0.01636540726+0.0165473713j),(-0.0004505354035+0.02321358904j),(-0.01488910767+0.01844377622j),(-0.02295650018+0.00466086735j),(-0.02278834906-0.0115563784j),(-0.01080514109-0.02267907002j),(0.007116112296-0.02367980493j),(0.01909907282-0.01423527852j),(0.02203412508+0.001252784883j),(0.01722533858+0.01579953089j),(0.003376494362+0.02302800371j),(-0.01392324509+0.01989783333j),(-0.02332442317+0.007897386391j),(-0.02242407954-0.007714551569j),(-0.01479039689-0.02027925198j),(-0.000586023826-0.02460271414j),(0.01556308812-0.01902640524j),(0.02316356448-0.005968528362j),(0.02000141504+0.009167743001j),(0.01097100345+0.02027626426j),(-0.002858380583+0.02302807697j),(-0.01805371521+0.01648252895j),(-0.02499263216+0.003309438618j),(-0.02108549994-0.01133672567j),(-0.01173048774-0.02186670599j),(0.001437027214-0.02440559092j),(0.01616261244-0.01815035832j),(0.02361392121-0.005524638421j),(0.02035897112+0.008794739918j),(0.01160850318+0.01963608052j),(-0.0006829331157+0.02322146277j),(-0.0153558421+0.01842755248j),(-0.02432977359+0.007043604615j),(-0.02302648003-0.006931160612j),(-0.01589046895-0.01871631939j),(-0.00494560836-0.02441482212j),(0.009712520641-0.02226309709j),(0.0208487818-0.01309089993j),(0.02264417347+3.202620283e-05j),(0.01831983725+0.01284785358j),(0.009680541098+0.02133237982j),(-0.00432466786+0.02294133375j),(-0.01758712185+0.01729918407j),(-0.02321968675+0.006236209414j),(-0.0229506205-0.006829896085j),(-0.01808738721-0.01800104919j),(-0.006254979515-0.02406876191j),(0.008040745571-0.0233788613j),(0.01733863488-0.0162432038j),(0.02190646336-0.004793248852j),(0.02242590522+0.007714738289j),(0.01505188903+0.0178573552j),(0.002106877973+0.02294692989j),(-0.009176924466+0.02171704435j),(-0.0180416832+0.01462119727j),(-0.02475512956+0.003619071172j),(-0.024122697-0.008415280713j),(-0.01583785917-0.01843435282j),(-0.00596670534-0.02398009775j),(0.004508349879-0.02379116006j),(0.01611253158-0.01804052982j),(0.02294368645-0.008201415992j),(0.02211586522+0.003338129959j),(0.01784623247+0.01386339894j),(0.01048009589+0.02100085999j),(-0.001750642473+0.02323179542j),(-0.01345595462+0.02016051414j),(-0.02000096972+0.0125648018j),(-0.0238049875+0.002185220636j),(-0.02421975376-0.008722563548j),(-0.01747192359-0.01788769543j),(-0.007038726573-0.0234646539j),(0.002170753528-0.02440081434j),(0.01175464646-0.02062643486j),(0.0207169327-0.01299072158j),(0.02346883003-0.00304125379j),(0.02083858706+0.007279606987j),(0.01667241664+0.01602992029j),(0.008825739039+0.02165163371j),(-0.002838905964+0.0232109426j),(-0.0123301846+0.02051828168j),(-0.01846951986+0.01414862417j),(-0.02388784105+0.005295844534j),(-0.0253242486-0.004492678751j),(-0.02031503954-0.01357810533j),(-0.01345863359-0.02048780373j),(-0.006274056328-0.02417055947j),(0.003921286248-0.02414193712j),(0.01378872283-0.02049817647j),(0.01892821592-0.01387868715j),(0.02195495841-0.005358165596j),(0.02363970195+0.003762861747j),(0.01989853084+0.01216993208j),(0.01234132338+0.01869522171j),(0.005492856344+0.02247870232j),(-0.002490810564+0.02309163703j),(-0.01240505206+0.02054729311j),(-0.01912940372+0.01525676427j),(-0.02203877679+0.007976525042j),(-0.02457274055-0.0003116467583j),(-0.0242960404-0.008565145566j),(-0.01878307361-0.01579773182j),(-0.01234657657-0.0211761561j),(-0.006411597581-0.02413284134j),(0.002221130001-0.02441814858j),(0.01108492715-0.02207914649j),(0.01612378426-0.0174431857j),(0.02001297285-0.01108422935j),(0.02380601751-0.003722349314j),(0.02326592965+0.003872417053j),(0.01924535716+0.010935507j),(0.01574998498+0.01678818416j),(0.01055140812+0.02092215587j),(0.002061995042+0.02301790871j),(-0.005146162057+0.02294505149j),(-0.0103398275+0.02078506458j),(-0.01690377911+0.01680869881j),(-0.02234635513+0.01141107749j),(-0.0235156487+0.005080501238j),(-0.02384063289-0.001630864638j),(-0.02425585076-0.00818041296j),(-0.02086011861-0.0140845045j),(-0.01520585205-0.01892481511j),(-0.01103247838-0.02238220002j),(-0.00567572082-0.02427431512j),(0.002126769963-0.0245374816j),(0.007950507106-0.0232089204j),(0.01186919681-0.02044091313j),(0.01731457915-0.01647802751j),(0.02157465932-0.01160797967j),(0.0220910081-0.006154356024j),(0.02257427837-0.0004691848469j),(0.02342281337+0.005115249737j),(0.02076793852+0.01030769113j),(0.01653479973+0.01484523395j),(0.01394168216+0.01851588038j),(0.009840005506+0.02118509827j),(0.003298438177+0.02277411881j),(-0.001412214314+0.02324983381j),(-0.005038495335+0.02264733932j),(-0.01084963154+0.02105573162j),(-0.01580064522+0.01858533848j),(-0.01780739118+0.01537762481j),(-0.02066594978+0.01160848549j),(-0.02414093461+0.007452049278j),(-0.02439528073+0.003073210504j),(-0.02365644938-0.001353954891j),(-0.02456911677-0.005667551531j),(-0.02357209146-0.009740298006j),(-0.02009757557-0.01345814997j),(-0.01821533552-0.01671784863j),(-0.01654175788-0.01945453646j),(-0.01202316639-0.02163119404j),(-0.007965602981-0.02321594747j),(-0.00591499412-0.02420175407j),(-0.002001846082-0.02461363047j),(0.002983098221-0.02447907468j),(0.00537417254-0.02382995126j),(0.007740132163-0.02272377478j),(0.01219204794-0.02122313903j),(0.01488975217-0.0193786065j),(0.01569038455-0.01725199026j),(0.01843514174-0.01491508585j),(0.02115096198-0.01242208537j),(0.02104380314-0.009821483946j),(0.02159536576-0.007173805766j),(0.02374376829-0.004527585488j),(0.02354278372-0.001912782919j),(0.02223447688+0.0006328437941j),(0.02315485445+0.003071921212j),(0.02333245498+0.005389415036j),(0.02110802925+0.00757224555j),(0.0204209202+0.009597631595j),(0.0208803121+0.01145875223j),(0.0188326483+0.0131614099j),(0.01670877557+0.01469894596j),(0.01691621942+0.01606777924j),(0.01578864473+0.0172827672j),(0.0129528974+0.018352125j),(0.01232615602+0.01927437705j),(0.0122147569+0.02006391268j),(0.009656241883+0.02073921657j),(0.007975989315+0.02130274756j),(0.008372222902+0.02176271521j),(0.006899618514+0.02214072729j),(0.004508753803+0.0224452974j),(0.004648520361+0.02267796918j),(0.004522531632+0.02285606313j),(0.002201490517+0.02299395213j),(0.001529996121+0.02309015174j),(0.002369985663+0.02315278331j),(0.0009564723767+0.02319859214j),(-0.0005389466648+0.02322791133j),(0.0004792511408+0.02323906065j),(0.0004412699573+0.02324555704j),(-0.001322257818+0.0232524075j),(-0.0008803887415+0.0232516657j),(0.0003164062323+0.0232485202j),(-0.0008803887419+0.02325166571j),(-0.001322257818+0.0232524075j),(0.0004412699578+0.02324555704j),(0.0004792511401+0.02323906065j),(-0.000538946666+0.02322791133j),(0.0009564723766+0.02319859214j),(0.002369985664+0.0231527833j),(0.001529996122+0.02309015174j),(0.002201490518+0.02299395213j),(0.004522531633+0.02285606313j),(0.004648520361+0.02267796918j),(0.004508753801+0.0224452974j),(0.006899618513+0.02214072729j),(0.008372222902+0.02176271521j),(0.007975989317+0.02130274756j),(0.009656241883+0.02073921657j),(0.0122147569+0.02006391268j),(0.01232615602+0.01927437705j),(0.0129528974+0.018352125j),(0.01578864473+0.0172827672j),(0.01691621942+0.01606777924j),(0.01670877557+0.01469894596j),(0.0188326483+0.0131614099j),(0.0208803121+0.01145875223j),(0.0204209202+0.009597631593j),(0.02110802925+0.00757224555j),(0.02333245498+0.005389415037j),(0.02315485445+0.003071921214j),(0.02223447688+0.0006328437951j),(0.02354278372-0.001912782919j),(0.02374376829-0.004527585488j),(0.02159536576-0.007173805767j),(0.02104380314-0.009821483946j),(0.02115096198-0.01242208537j),(0.01843514174-0.01491508585j),(0.01569038455-0.01725199026j),(0.01488975217-0.0193786065j),(0.01219204794-0.02122313903j),(0.007740132162-0.02272377478j),(0.005374172541-0.02382995126j),(0.002983098221-0.02447907468j),(-0.002001846082-0.02461363047j),(-0.00591499412-0.02420175408j),(-0.007965602981-0.02321594747j),(-0.01202316639-0.02163119404j),(-0.01654175788-0.01945453646j),(-0.01821533552-0.01671784863j),(-0.02009757557-0.01345814997j),(-0.02357209146-0.009740298006j),(-0.02456911677-0.00566755153j),(-0.02365644938-0.001353954891j),(-0.02439528073+0.003073210504j),(-0.02414093461+0.007452049278j),(-0.02066594978+0.01160848549j),(-0.01780739118+0.01537762481j),(-0.01580064522+0.01858533848j),(-0.01084963154+0.02105573162j),(-0.005038495333+0.02264733933j),(-0.001412214312+0.02324983382j),(0.003298438175+0.02277411881j),(0.009840005505+0.02118509827j),(0.01394168216+0.01851588038j),(0.01653479973+0.01484523395j),(0.02076793852+0.01030769113j),(0.02342281337+0.005115249736j),(0.02257427837-0.0004691848472j),(0.0220910081-0.006154356024j),(0.02157465932-0.01160797967j),(0.01731457915-0.01647802751j),(0.01186919681-0.02044091313j),(0.007950507106-0.0232089204j),(0.002126769964-0.0245374816j),(-0.005675720819-0.02427431512j),(-0.01103247838-0.02238220002j),(-0.01520585205-0.01892481511j),(-0.02086011861-0.0140845045j),(-0.02425585076-0.00818041296j),(-0.02384063289-0.001630864637j),(-0.0235156487+0.00508050124j),(-0.02234635513+0.01141107749j),(-0.01690377911+0.01680869881j),(-0.0103398275+0.02078506458j),(-0.005146162057+0.02294505149j),(0.002061995043+0.02301790871j),(0.01055140812+0.02092215587j),(0.01574998498+0.01678818416j),(0.01924535716+0.01093550701j),(0.02326592965+0.003872417054j),(0.02380601751-0.003722349316j),(0.02001297285-0.01108422935j),(0.01612378426-0.0174431857j),(0.01108492715-0.02207914649j),(0.00222113-0.02441814858j),(-0.006411597581-0.02413284134j),(-0.01234657657-0.0211761561j),(-0.01878307361-0.01579773182j),(-0.0242960404-0.008565145566j),(-0.02457274055-0.0003116467568j),(-0.02203877678+0.007976525044j),(-0.01912940372+0.01525676427j),(-0.01240505206+0.02054729311j),(-0.002490810563+0.02309163704j),(0.005492856347+0.02247870232j),(0.01234132338+0.01869522171j),(0.01989853084+0.01216993208j),(0.02363970195+0.003762861746j),(0.02195495841-0.005358165596j),(0.01892821592-0.01387868715j),(0.01378872283-0.02049817647j),(0.003921286247-0.02414193712j),(-0.006274056328-0.02417055947j),(-0.01345863359-0.02048780373j),(-0.02031503954-0.01357810533j),(-0.0253242486-0.004492678752j),(-0.02388784105+0.005295844533j),(-0.01846951986+0.01414862417j),(-0.0123301846+0.02051828168j),(-0.002838905963+0.0232109426j),(0.00882573904+0.02165163371j),(0.01667241664+0.0160299203j),(0.02083858706+0.007279606989j),(0.02346883003-0.003041253789j),(0.0207169327-0.01299072158j),(0.01175464646-0.02062643486j),(0.00217075353-0.02440081434j),(-0.007038726572-0.0234646539j),(-0.01747192359-0.01788769543j),(-0.02421975376-0.008722563548j),(-0.0238049875+0.002185220636j),(-0.02000096972+0.0125648018j),(-0.01345595462+0.02016051414j),(-0.001750642473+0.02323179542j),(0.01048009589+0.02100085999j),(0.01784623246+0.01386339894j),(0.02211586522+0.003338129959j),(0.02294368645-0.008201415993j),(0.01611253158-0.01804052982j),(0.004508349878-0.02379116006j),(-0.00596670534-0.02398009775j),(-0.01583785916-0.01843435282j),(-0.024122697-0.008415280715j),(-0.02475512956+0.003619071172j),(-0.0180416832+0.01462119728j),(-0.009176924465+0.02171704435j),(0.002106877974+0.02294692989j),(0.01505188903+0.0178573552j),(0.02242590522+0.007714738289j),(0.02190646336-0.004793248852j),(0.01733863488-0.0162432038j),(0.00804074557-0.0233788613j),(-0.006254979516-0.02406876191j),(-0.01808738721-0.01800104919j),(-0.0229506205-0.006829896084j),(-0.02321968675+0.006236209414j),(-0.01758712185+0.01729918407j),(-0.00432466786+0.02294133375j),(0.009680541098+0.02133237982j),(0.01831983726+0.01284785358j),(0.02264417347+3.202620237e-05j),(0.0208487818-0.01309089994j),(0.009712520641-0.0222630971j),(-0.004945608359-0.02441482212j),(-0.01589046896-0.01871631939j),(-0.02302648004-0.006931160612j),(-0.02432977359+0.007043604614j),(-0.0153558421+0.01842755248j),(-0.0006829331158+0.02322146277j),(0.01160850318+0.01963608052j),(0.02035897112+0.008794739916j),(0.02361392121-0.005524638422j),(0.01616261244-0.01815035832j),(0.001437027214-0.02440559092j),(-0.01173048774-0.02186670599j),(-0.02108549994-0.01133672567j),(-0.02499263216+0.003309438619j),(-0.01805371521+0.01648252894j),(-0.002858380584+0.02302807697j),(0.01097100345+0.02027626426j),(0.02000141504+0.009167743001j),(0.02316356448-0.005968528363j),(0.01556308812-0.01902640524j),(-0.0005860238265-0.02460271414j),(-0.01479039689-0.02027925198j),(-0.02242407954-0.007714551568j),(-0.02332442317+0.007897386393j),(-0.01392324509+0.01989783333j),(0.003376494364+0.02302800371j),(0.01722533858+0.01579953088j),(0.02203412508+0.001252784885j),(0.01909907282-0.01423527852j),(0.007116112297-0.02367980493j),(-0.01080514109-0.02267907002j),(-0.02278834906-0.0115563784j),(-0.02295650018+0.00466086735j),(-0.01488910767+0.01844377622j),(-0.0004505354028+0.02321358904j),(0.01636540726+0.01654737131j),(0.02408868882+0.001521355832j),(0.01780746031-0.01463939136j),(0.004339735544-0.02399750513j),(-0.0108074976-0.02179632558j),(-0.02336646602-0.008970444325j),(-0.0240414492+0.008106482562j),(-0.01056261593+0.02073902663j),(0.006454656393+0.02235182775j),(0.01848478591+0.01195456416j),(0.02279631836-0.005151485186j),(0.01470948658-0.01995331254j),(-0.004037690175-0.02447031157j),(-0.0198369883-0.01613719424j),(-0.02352324274+0.0006586946574j),(-0.01677227426+0.01678392434j),(-0.00161704505+0.02325426605j),(0.01655129579+0.01630262747j),(0.02427551113-0.0002920810824j),(0.01573548834-0.01716655452j),(-0.0004567702941-0.02461599305j),(-0.01580783879-0.01818856225j),(-0.02475324976-0.00146665482j),(-0.01923899508+0.01577372698j),(-0.0003774804333+0.02324361034j),(0.016882683+0.01634453429j),(0.02207394219-0.0009104011182j),(0.01561682891-0.01810014208j),(-0.0006887075807-0.02460347269j),(-0.01944832155-0.01623274265j),(-0.02544633651+0.001918420921j),(-0.01396756991+0.01847206073j),(0.003985685984+0.02286106293j),(0.01825976566+0.01211321962j),(0.02271513331-0.006987599466j),(0.01129373291-0.02202903552j),(-0.01018382789-0.02303768211j),(-0.02369929362-0.009200508685j),(-0.02065266754+0.0103793428j),(-0.006471600019+0.0225549535j),(0.01177695838+0.01894030687j),(0.02383744195+0.001829952236j),(0.01763295299-0.01707070021j),(-0.002960402228-0.02460042068j),(-0.01983124079-0.01536075234j),(-0.02278790565+0.004295549414j),(-0.01239447789+0.0204650356j),(0.007337681212+0.02146351119j),(0.02324033042+0.006399244629j),(0.01978114878-0.01387760281j),(0.0003566817348-0.02450457242j),(-0.01749253081-0.01751583993j),(-0.02325167033+0.002066004764j),(-0.01423289506+0.0196410438j),(0.006670052527+0.02184053986j),(0.0233373765+0.006826292727j),(0.01925222288-0.01400333274j),(-0.0003936746043-0.02456783133j),(-0.01797630221-0.01652361071j),(-0.02318951261+0.004006549919j),(-0.01229962847+0.02088014235j),(0.009990077749+0.02057049959j),(0.02432904949+0.003163539131j),(0.01603080378-0.01739735653j),(-0.005203117161-0.02439014144j),(-0.02076462287-0.01194500247j),(-0.02157678726+0.009853016861j),(-0.006035725632+0.02293082776j),(0.01640499203+0.01621400352j),(0.02422203961-0.004798462046j),(0.008619504939-0.02235646512j),(-0.01354804267-0.02140790168j),(-0.02321846897-0.002596507285j),(-0.01558871879+0.01793008784j),(0.004828306503+0.02222882705j),(0.02281168459+0.006349396995j),(0.01898449628-0.01580108148j),(-0.004230025587-0.0245108554j),(-0.02231529073-0.01185566625j),(-0.02014971273+0.01092202202j),(-0.002670252802+0.02319743755j),(0.01721962677+0.01360959902j),(0.02273715882-0.009202657531j),(0.004824881205-0.02415294212j),(-0.0194741042-0.01720218694j),(-0.02382907617+0.005282383204j),(-0.006354494512+0.02216346301j),(0.01426117613+0.01732001796j),(0.02188541508-0.004813877319j),(0.009325896999-0.02302566144j),(-0.01515084748-0.01956717697j),(-0.02597087665+0.002354833686j),(-0.009558343533+0.02131313449j),(0.01480401016+0.01853600173j),(0.02186006318-0.003385598483j),(0.008223737578-0.02266289718j),(-0.01353509298-0.01982348965j),(-0.0246845166+0.002456190625j),(-0.01096980119+0.02156620902j),(0.01550401237+0.01783345592j),(0.02373231669-0.005043817992j),(0.005244489394-0.02342839413j),(-0.01721724149-0.01807217521j),(-0.02222141041+0.005591812865j),(-0.006763008747+0.02266576581j),(0.01634403647+0.01488173543j),(0.02294408661-0.009618162484j),(0.002004032383-0.02452282128j),(-0.0224884369-0.01360292156j),(-0.02085972937+0.01140687537j),(0.002206568259+0.02319328413j),(0.02010562606+0.008654919586j),(0.01672782004-0.01629739512j),(-0.005058033897-0.02387362395j),(-0.02432299059-0.005406445817j),(-0.01671207616+0.01841961978j),(0.01134055331+0.02055943865j),(0.02427774989-0.001564872009j),(0.007081794231-0.02270907373j),(-0.0169220498-0.01846065555j),(-0.02182919963+0.006444774518j),(-0.004391681356+0.02307284635j),(0.01841571757+0.01179366494j),(0.02049339251-0.01427181351j),(-0.004570911656-0.02422195379j),(-0.02579035596-0.006061335927j),(-0.01451204044+0.01856168784j),(0.0129522883+0.0199690089j),(0.02179778902-0.003698247348j),(0.004842494863-0.02374139622j),(-0.01773933786-0.01551788239j),(-0.02160325628+0.01104641566j),(0.0005289735184+0.02308185002j),(0.02344225769+0.00544769557j),(0.01484128462-0.01990066692j),(-0.01495067401-0.0210387842j),(-0.02458119264+0.003604648187j),(-0.003330705672+0.02280409724j),(0.01897185574+0.01194744334j),(0.01680600922-0.01521041295j),(-0.006109363403-0.02362157633j),(-0.02386298311-0.002177004426j),(-0.0122304571+0.0212516311j),(0.01693994391+0.01583169581j),(0.0224830369-0.01143137782j),(-0.004910486392-0.02443475656j),(-0.0251860662-0.005759968915j),(-0.01127656426+0.01972935486j),(0.01469406219+0.01772826019j),(0.01970911688-0.009245266253j),(-0.0007658106792-0.0246184847j),(-0.02227755091-0.007227950064j),(-0.01580649201+0.01920143301j),(0.01360882914+0.01812643147j),(0.02378658526-0.009111732782j),(-0.002571901563-0.02458908751j),(-0.02565662449-0.006542837094j),(-0.01155500052+0.01975600929j),(0.01622190034+0.01712301301j),(0.01888047175-0.01087117898j),(-0.004162688518-0.02435118419j),(-0.02242466748-0.003814565091j),(-0.01150540881+0.02128722636j),(0.01650201813+0.01448769654j),(0.02091743554-0.01448048554j),(-0.008500642625-0.02323444859j),(-0.02674341945+0.00121104407j),(-0.004132989058+0.02283662938j),(0.02266147659+0.00951942646j),(0.01279505847-0.01903359227j),(-0.01539189639-0.02011277285j),(-0.02067638062+0.008077064301j),(0.001964282352+0.02304820206j),(0.02107809858+0.001908770427j),(0.00900412122-0.02325157483j),(-0.0195766687-0.01376645055j),(-0.02025329258+0.01591659941j),(0.01163616624+0.01985877182j),(0.02434980177-0.00818057469j),(-0.004325580573-0.0244947017j),(-0.02609207319-0.003453017362j),(-0.006218379201+0.02193826453j),(0.0203515157+0.01152570697j),(0.01298284142-0.01832861444j),(-0.01392619773-0.02004455463j),(-0.02039112234+0.009329935358j),(0.003011292434+0.02259919068j),(0.02224316642-0.001878234728j),(0.005098086891-0.02445625559j),(-0.02382555471-0.008173066834j),(-0.01448306326+0.02039726115j),(0.01972903183+0.01419113107j),(0.01869325086-0.01662359554j),(-0.01590714966-0.02094286208j),(-0.02293773354+0.00850435388j),(0.007484052884+0.02255030384j),(0.02188519673-0.002476815714j),(-0.0008119648353-0.02451666126j),(-0.02161819155-0.006150787961j),(-0.008735021115+0.02157674595j),(0.01729386287+0.01121278224j),(0.01473328353-0.01966942028j),(-0.01507233843-0.01779039698j),(-0.02194780734+0.01377835245j),(0.009855002677+0.02014246589j),(0.02431618706-0.009925733552j),(-0.007361584527-0.02374635447j),(-0.02715802367+0.003051297487j),(0.002042323394+0.02318760142j),(0.02508148078+0.0009507461133j),(0.0006942225509-0.02418076205j),(-0.02407515901-0.007313099069j),(-0.006480486829+0.02145611499j),(0.01928169239+0.01032723867j),(0.009755994727-0.02078996524j),(-0.01697522691-0.0154034344j),(-0.0158397276+0.01690847968j),(0.01227232032+0.01699012973j),(0.01882296758-0.01553859422j),(-0.01112007364-0.02062811294j),(-0.02378173058+0.01133246568j),(0.008093516066+0.02086811808j),(0.0247790909-0.009936334896j),(-0.008527116885-0.0233251352j),(-0.02712152088+0.005928424096j),(0.006476183142+0.02259677524j),(0.0253236512-0.004895754877j),(-0.006988916992-0.02431861002j),(-0.02525370487+0.001374442023j),(0.00414526229+0.02308420992j),(0.0219443548-0.0009241779171j),(-0.0033197787-0.02450351644j),(-0.02158557455-0.00193694722j),(-0.0008752588837+0.02312786461j),(0.01923000274+0.001664505201j),(0.002484593646-0.02451536068j),(-0.02076126733-0.003758389689j),(-0.006443041693+0.02316425737j),(0.02066739482+0.002697568156j),(0.006614649216-0.02458665202j),(-0.02415476247-0.004009766845j),(-0.008095351458+0.02324835284j),(0.02510634216+0.002201819742j),(0.005223709799-0.02464550904j),(-0.02836803177-0.002822896202j),(-0.003761343361+0.02324274105j),(0.02781625315+0.000388566117j),(-0.00128073623-0.02454334708j),(-0.0286558423-0.0004404524798j),(0.003657098899+0.02301762496j),(0.02539327416-0.002528432829j),(-0.008211102935-0.02416240671j),(-0.02395643425+0.003006880807j),(0.008947112269+0.02242111663j),(0.01945365527-0.006527673071j),(-0.01129657041-0.02324071205j),(-0.01810401948+0.007585294754j),(0.01002864188+0.02099717393j),(0.01488878933-0.0116834154j),(-0.01129112483-0.02106654187j),(-0.01549286992+0.01324316043j),(0.01029418305+0.01777156517j),(0.01409109334-0.01765057549j),(-0.01318898513-0.01647711301j),(-0.01551786005+0.01917698223j),(0.01470610775+0.01155884858j),(0.01331571759-0.02305084778j),(-0.02012832429-0.008512086017j),(-0.01212828059+0.02341210137j),(0.02314715201+0.001919847533j),(0.005865683686-0.02542187822j),(-0.02812617195+0.002456267693j),(-6.551914949e-05+0.02325091505j),(0.0282447916-0.009743356611j),(-0.01012666959-0.02221122116j),(-0.0279650339+0.01391509195j),(0.01789655712+0.01674702697j),(0.021231637-0.01991358864j),(-0.02712366762-0.01254532629j),(-0.01382006336+0.02165759675j),(0.03061765976+0.004482000386j),(0.00125990576-0.02419953472j),(-0.03264906158+0.001331260221j),(0.009191165524+0.02174429683j),(0.02717020851-0.009673797646j),(-0.02100507491-0.0197865625j),(-0.02013740843+0.01423875096j),(0.02669948572+0.01307901813j),(0.007370056174-0.01981270234j),(-0.03041419475-0.007693680538j),(0.003560344437+0.02032242003j),(0.02613370985-0.00110026042j),(-0.01587075338-0.02100192961j),(-0.01996885704+0.00686495432j),(0.02194209656+0.01638855687j),(0.007945969394-0.01418903045j),(-0.0259167486-0.01240662815j),(0.002183091451+0.0167576054j),(0.02189980538+0.004259491067j),(-0.01354733166-0.01954742386j),(-0.01618443688+0.001594666833j),(0.01856655485+0.01685224774j),(0.004966748158-0.009643829296j),(-0.0215425626-0.01439357569j),(0.003914948747+0.01340729557j),(0.01681547968+0.007234146266j),(-0.01363319341-0.01765317051j),(-0.01091827431-0.00176727441j),(0.01679010082+0.01645045511j),(0.0002148935645-0.006479990961j),(-0.01797618582-0.01530754046j),(0.007421347122+0.01093742012j),(0.01186122062+0.009111269674j),(-0.01528831455-0.01622318648j),(-0.005267471371-0.00413669876j)]'
  states: {}
- name: print_count
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: recording
  id: wasm_public_http_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    repeat: 'False'
    type: complex
    url: https://raw.githubusercontent.com/RUB-SysSec/DroneSecurity/public_squash/samples/mini2_sm
    vlen: '1'
  states: {}
- name: resampler
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    fbw: '0.4'
    interp: '192'
    type: ccc
  states: {}
- name: zero_padding
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}

connections:
- [align_frame_start, '0', detect_frames, '0']
- [append_padding, '0', mixer, '0']
- [channel_shift, '0', mixer, '1']
- [correlation_power, '0', detect_frames, '1']
- {src_blk_id: detect_frames, src_port_id: pdus, snk_blk_id: detection_count, snk_port_id: in}
- {src_blk_id: detection_count, src_port_id: count, snk_blk_id: print_count, snk_port_id: print}
- {src_blk_id: detection_count, src_port_id: out, snk_blk_id: print_count, snk_port_id: store}
- [mixer, '0', resampler, '0']
- [padding_head, '0', append_padding, '1']
- [preamble_correlator, '0', correlation_power, '0']
- [recording, '0', append_padding, '0']
- [resampler, '0', align_frame_start, '0']
- [resampler, '0', preamble_correlator, '0']
- [zero_padding, '0', padding_head, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
