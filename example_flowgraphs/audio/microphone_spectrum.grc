options:
  parameters:
    author: Claude
    description: Live spectrum and waveform of whatever the computer's microphone hears
    generate_options: qt_gui
    id: Microphone_Spectrum
    title: Microphone Spectrum
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Input gain
    min_len: '240'
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: amplify
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    mode: scalar
    type: float
  states: {}
- name: microphone
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    label1: Microphone
    legend: 'False'
    marker1: '-1'
    marker2: '-1'
    name: Microphone Spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}
- name: waveform
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: Microphone
    legend: 'False'
    name: Microphone Waveform
    samp_rate: samp_rate
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '10'
    ymin: '-10'
    yunit: ''
  states: {}

connections:
- [amplify, '0', spectrum, '0']
- [amplify, '0', waveform, '0']
- [microphone, '0', amplify, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
