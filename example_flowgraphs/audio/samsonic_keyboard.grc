options:
  parameters:
    author: Marc
    description: Play synth notes and chords on the SamSonic musical keyboard
    generate_options: qt_gui
    id: SamSonic_Musical_Keyboard
    title: SamSonic Musical Keyboard
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    maxoutbuf: '16'
    type: float
  states: {}
- name: keyboard
  id: wasm_musical_keyboard_source
  parameters:
    amplitude: '0.18'
    attack_ms: '5'
    decay_ms: '180'
    default_chord: none
    filter_cutoff_hz: '700'
    filter_envelope_octaves: '3'
    filter_resonance: '0.25'
    first_note: '48'
    maxoutbuf: '16'
    octaves: '3'
    release_ms: '120'
    samp_rate: samp_rate
    saturation_drive: '1'
    sustain_level: '0.6'
    tuning_hz: '440'
    unison_detune_cents: '9'
    unison_voices: '2'
    waveform: saw
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enjoy! You can also play notes using the keyboard!  Try selection a chord for more fun.
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    name: Scope
    samp_rate: samp_rate
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '0.3'
    ymin: '-0.3'
    yunit: ''
  states: {}
- name: speakers
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    label1: SamSonic output
    legend: 'False'
    marker1: '-1'
    marker2: '-1'
    name: SamSonic Spectrum
    samp_rate: samp_rate/4
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"keyboard":[0,0,12,4],"qtgui_time_sink_x_0":[6,4,6,4],"spectrum":[0,4,6,4]}'
    row_height: '60'
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', spectrum, '0']
- [keyboard, '0', blocks_keep_one_in_n_0, '0']
- [keyboard, '0', speakers, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
