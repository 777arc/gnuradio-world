options:
  parameters:
    author: Mike Warot
    description: This is a really simple audio frequency shifter
    generate_options: qt_gui
    id: Audio_Frequency_Shifter
    title: Audio Frequency Shifter
  states: {}

blocks:
- name: offset_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-2000'
    step: '1'
    stop: '2000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    name: Mic Input
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    yunit: ''
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    name: Output
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    yunit: ''
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
