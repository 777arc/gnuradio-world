options:
  parameters:
    author: Claude
    description: Broadcast FM receiver - a hosted 250 kHz IQ recording demodulated to audio and played through the speakers, with a live volume control
    generate_options: qt_gui
    id: FM_Receiver_from_Recording
    title: FM Receiver from Recording
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    min_len: '240'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: audio_spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: Audio
    legend: 'False'
    marker1: '-1'
    marker2: '-1'
    name: Demodulated audio (19 kHz stereo pilot visible)
    bw: audio_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: fm_rds_250k_1Msamples
    repeat: 'True'
    type: complex
  states: {}
- name: resample_to_quad
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: rf_spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    fc: '100000000'
    fftsize: '1024'
    grid: 'True'
    label1: FM station
    legend: 'False'
    marker1: '-1'
    marker2: '-1'
    name: RF spectrum
    bw: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: speakers
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: volume_gain
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    mode: scalar
    type: float
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}
- name: wbfm_demod
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    deemph_tau: '0.000075'
    quad_rate: quad_rate
  states: {}

connections:
- [recording, '0', resample_to_quad, '0']
- [recording, '0', rf_spectrum, '0']
- [resample_to_quad, '0', wbfm_demod, '0']
- [volume_gain, '0', audio_spectrum, '0']
- [volume_gain, '0', speakers, '0']
- [wbfm_demod, '0', volume_gain, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
