options:
  parameters:
    author: Claude
    description: A tone played through the computer's speakers, with live frequency and volume controls
    generate_options: qt_gui
    id: Audio_Tone_Generator
    title: Audio Tone Generator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tone_frequency
  id: variable_qtgui_range
  parameters:
    label: Tone frequency (Hz)
    min_len: '240'
    start: '100'
    step: '10'
    stop: '2000'
    value: '440'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    min_len: '240'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: speakers
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amplitude: volume
    frequency: tone_frequency
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}
- name: waveform
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: Tone
    legend: 'False'
    name: What the speakers are playing
    samp_rate: samp_rate
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.2'
    ymin: '-1.2'
    yunit: ''
  states: {}

connections:
- [tone, '0', speakers, '0']
- [tone, '0', waveform, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
