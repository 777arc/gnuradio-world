options:
  parameters:
    author: Marc
    description: Decodes RDS from the 57 kHz subcarrier of a broadcast FM station.
    generate_options: qt_gui
    id: RDS_Receiver
    title: RDS Receiver
  states: {}

blocks:
- name: rds_carrier
  id: variable
  parameters:
    value: '57000'
  states: {}
- name: rds_samp_rate
  id: variable
  parameters:
    value: '19000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '0.002'
    reference: '0.585'
    type: complex
  states: {}
- name: biphase_delay
  id: blocks_delay
  parameters:
    delay: '8'
    type: complex
  states: {}
- name: biphase_sub
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: constellation_receiver
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi/100
  states: {}
- name: constellation_sink
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    name: RDS BPSK
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: diff_decoder
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: discard_error
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: discard_freq
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: discard_phase
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: mpx_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*75e3)
  states: {}
- name: rds_decoder
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_lo
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-rds_carrier'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: rds_lpf
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rds_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: rds_panel
  id: rds_panel
  parameters:
    freq: '100000000'
  states: {}
- name: rds_parser
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: fm_rds_250k_1Msamples
    repeat: 'True'
    type: complex
  states: {}
- name: resample_19k
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '19'
    type: ccc
  states: {}
- name: rrc_filter
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: '151'
    samp_rate: rds_samp_rate
    sym_rate: rds_samp_rate/8
    type: fir_filter_ccf
  states: {}
- name: symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [agc, '0', symbol_sync, '0']
- [biphase_delay, '0', biphase_sub, '0']
- [biphase_sub, '0', agc, '0']
- [constellation_receiver, '0', diff_decoder, '0']
- [constellation_receiver, '1', discard_error, '0']
- [constellation_receiver, '2', discard_phase, '0']
- [constellation_receiver, '3', discard_freq, '0']
- [constellation_receiver, '4', constellation_sink, '0']
- [diff_decoder, '0', rds_decoder, '0']
- [mpx_to_complex, '0', rds_mixer, '0']
- [quad_demod, '0', mpx_to_complex, '0']
- {src_blk_id: rds_decoder, src_port_id: out, snk_blk_id: rds_parser, snk_port_id: in}
- [rds_lo, '0', rds_mixer, '1']
- [rds_lpf, '0', resample_19k, '0']
- [rds_mixer, '0', rds_lpf, '0']
- {src_blk_id: rds_parser, src_port_id: out, snk_blk_id: rds_panel, snk_port_id: in}
- [recording, '0', throttle, '0']
- [resample_19k, '0', rrc_filter, '0']
- [rrc_filter, '0', biphase_delay, '0']
- [rrc_filter, '0', biphase_sub, '1']
- [symbol_sync, '0', constellation_receiver, '0']
- [throttle, '0', quad_demod, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
