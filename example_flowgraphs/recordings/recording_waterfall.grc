options:
  parameters:
    author: Marc
    generate_options: qt_gui
    id: Recording_Waterfall_Test
    title: Recording Waterfall Test
  states: {}

blocks:
- name: complex5
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: source4
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: cellular_downlink_880MHz
    repeat: 'False'
    type: short
  states: {}
- name: throttle23
  id: blocks_throttle2
  parameters:
    samples_per_second: '100000'
    type: complex
  states: {}
- name: x2
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '1024'
    name: Waterfall
    bw: '32000'
    update_time: '0.1'
  states: {}

connections:
- [complex5, '0', throttle23, '0']
- [source4, '0', complex5, '0']
- [throttle23, '0', x2, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
