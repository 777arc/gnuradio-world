options:
  parameters:
    author: Marc
    description: Interactive real-time spectrum and waterfall display using gr-fosphor. The browser uses WebGPU when available and automatically falls back to Qt 6 CPU plots; the editor console reports which renderer was selected.
    generate_options: qt_gui
    id: fosphor_spectrum_waterfall
    title: Fosphor Spectrum and Waterfall
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: signal
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '6000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amplitude: '0.08'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.05'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fosphor
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {}

connections:
- [signal, '0', add, '0']
- [noise, '0', add, '1']
- [add, '0', throttle, '0']
- [throttle, '0', fosphor, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
