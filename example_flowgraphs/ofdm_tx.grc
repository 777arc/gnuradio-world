options:
  parameters:
    author: Marc
    generate_options: qt_gui
    id: OFDM_Tx
    title: OFDM Tx
  states: {}

blocks:
- name: stream1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length
    packet_len: '96'
    type: byte
  states: {}
- name: throttle4
  id: blocks_throttle
  parameters:
    samp_rate: '32000'
    type: complex
  states: {}
- name: wasm7
  id: digital_ofdm_tx_wasm
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    log: 'False'
    occupied_carriers: (list(range(-16, 0)) + list(range(1, 17)),)
    packet_len_key: length
    payload_mod: '"BPSK"'
    pilot_carriers: ()
    pilot_symbols: ()
    rolloff: '0'
    scramble_bits: 'False'
    sync_word1: ()
    sync_word2: ()
  states: {}
- name: x8
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: x9
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    marker1: '-1'
    name: Spectrum
    samp_rate: '32000'
    style1: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}

connections:
- [stream1, '0', wasm7, '0']
- [throttle4, '0', x9, '0']
- [wasm7, '0', throttle4, '0']
- [x8, '0', stream1, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
