options:
  parameters:
    author: gnuradio-world
    description: 32 synthetic NOAA HRPT minor frames (32 AVHRR scan lines, carrying this repo's own logo on channel 2) that exercise the real noaa_hrpt_deframer and hrpt_image_sink blocks end to end. See example_flowgraphs/gr-hrpt/README.md for how the fixture was generated and why the PLL/bit-slicer stage is skipped here.
    generate_options: qt_gui
    id: HRPT_NOAA_Synthetic_Image
    title: HRPT NOAA Synthetic Image
  states: {}

blocks:
- name: decode
  id: noaa_hrpt_decoder
  parameters:
    output: 'False'
    verbose: 'True'
  states: {}
- name: deframe
  id: noaa_hrpt_deframer
  parameters: {}
  states: {}
- name: image
  id: hrpt_image_sink
  parameters:
    channel: '2'
    image_width: '2048'
    invert: 'False'
    max_lines: '200'
    name: '"HRPT Image (channel 2)"'
    video_start: '751'
    words_per_line: '11090'
  states: {}
- name: src
  id: wasm_public_http_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    repeat: 'False'
    type: byte
    url: https://raw.githubusercontent.com/777arc/gnuradio-world/0fe7d7263adeb70c6c3af63f93b8cfb3ed2e4d9e/example_flowgraphs/hrpt/noaa_synthetic_symbols.bin
    vlen: '1'
  states: {}

connections:
- [deframe, '0', decode, '0']
- [deframe, '0', image, '0']
- [src, '0', deframe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
