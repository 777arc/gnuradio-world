options:
  parameters:
    author: PySDR
    description: Companion to the Filters chapter of PySDR
    generate_options: qt_gui
    id: PySDR__Low_Pass_Filtering_Out_an_Interferer
    title: 'PySDR: Low-Pass Filtering Out an Interferer'
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    label: Low-pass cutoff (Hz)
    start: '500'
    step: '100'
    stop: '20000'
    value: '3000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    label: Transition width (Hz)
    start: '200'
    step: '100'
    stop: '10000'
    value: '1000'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Before
    label2: After
    marker1: '-1'
    marker2: '-1'
    marker3: '-1'
    marker4: '-1'
    name: Before vs after filtering
    nconnections: '2'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    style3: '1'
    style4: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: interferer
  id: analog_sig_source_x
  parameters:
    amplitude: '0.3'
    frequency: '10000'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: noise_floor
  id: analog_noise_source_x
  parameters:
    amplitude: '0.02'
    seed: '1'
    type: complex
  states: {}
- name: note_int
  id: note
  parameters:
    note: Interferer at +10 kHz, plus a noise floor
  states: {}
- name: note_sig
  id: note
  parameters:
    note: 'Signal of interest: band-limited noise at 0 Hz'
  states: {}
- name: note_use
  id: note
  parameters:
    note: 'Drag cutoff below 10 kHz: the interferer drops below the old noise floor. Narrowing the transition width sharpens the edge, at the cost of more filter taps'
  states: {}
- name: soi_noise
  id: analog_noise_source_x
  parameters:
    amplitude: '0.7'
    seed: '0'
    type: complex
  states: {}
- name: soi_shape
  id: low_pass_filter
  parameters:
    cutoff_freq: '2500'
    decim: '1'
    gain: '3'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: user_lpf
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [add, '0', throttle, '0']
- [interferer, '0', add, '1']
- [noise_floor, '0', add, '2']
- [soi_noise, '0', soi_shape, '0']
- [soi_shape, '0', add, '0']
- [throttle, '0', freq_sink, '0']
- [throttle, '0', user_lpf, '0']
- [user_lpf, '0', freq_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
