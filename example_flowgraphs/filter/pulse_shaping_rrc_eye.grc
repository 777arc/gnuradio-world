options:
  parameters:
    author: Marc
    description: Companion to the Pulse Shaping chapter of PySDR
    generate_options: qt_gui
    id: PySDR__RRC_Pulse_Shaping__Eye_Diagram__and_Sampling_Instant
    title: 'PySDR: RRC Pulse Shaping, Eye Diagram, and Sampling Instant'
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    label: RRC roll-off (beta)
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.35'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise voltage
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: timing_offset
  id: variable_qtgui_range
  parameters:
    label: Sampling instant (samples)
    rangeType: int
    start: '0'
    step: '1'
    stop: '7'
    value: '0'
  states: {}
- name: bits_to_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    comment: BPSK, so we can ignore Q
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: const_sink
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: Sampled symbols
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: delay
  id: blocks_delay
  parameters:
    delay: timing_offset
    type: complex
  states: {}
- name: eye_sink
  id: qtgui_eye_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    type: float
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: Pulse-shaped spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: note_eye
  id: note
  parameters:
    note: |-
      The eye diagram overlays symbol periods. Raise beta and the eye opens wider in time; raise the noise and it closes vertically

      Sampling instant slides where the decimator takes its one sample in eight. At 0 it sits in the middle of the eye; walk it away and the constellation smears

      Random bits become BPSK symbols, one every 8 samples, then an RRC filter spreads each symbol over 11 symbol periods
  states: {}
- name: random_bits
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: rrc_rx
  id: root_raised_cosine_filter
  parameters:
    alpha: beta
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: rrc_tx
  id: root_raised_cosine_filter
  parameters:
    alpha: beta
    gain: sps
    interp: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: symbol_decim
  id: blocks_keep_one_in_n
  parameters:
    n: sps
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"beta":[0,0,4,1],"const_sink":[0,2,3,3],"eye_sink":[4,2,8,3],"freq_sink":[0,5,12,3],"noise_volt":[0,1,12,1],"timing_offset":[8,0,4,1]}'
    row_height: '60'
  states: {}

connections:
- [bits_to_bpsk, '0', rrc_tx, '0']
- [blocks_complex_to_float_0, '0', eye_sink, '0']
- [channel, '0', throttle, '0']
- [delay, '0', symbol_decim, '0']
- [random_bits, '0', bits_to_bpsk, '0']
- [rrc_rx, '0', blocks_complex_to_float_0, '0']
- [rrc_rx, '0', delay, '0']
- [rrc_rx, '0', freq_sink, '0']
- [rrc_tx, '0', channel, '0']
- [symbol_decim, '0', const_sink, '0']
- [throttle, '0', rrc_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
