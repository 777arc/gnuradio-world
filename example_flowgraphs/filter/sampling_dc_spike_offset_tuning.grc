options:
  parameters:
    author: PySDR
    description: Companion to the Sampling chapter of PySDR
    generate_options: qt_gui
    id: PySDR__DC_Spike_and_Offset_Tuning
    title: 'PySDR: DC Spike and Offset Tuning'
  states: {}

blocks:
- name: dc_amp
  id: variable_qtgui_range
  parameters:
    label: DC offset amplitude
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: soi_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: dc_offset
  id: blocks_add_const_vxx
  parameters:
    const: dc_amp
    type: complex
  states: {}
- name: freq_raw
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: 'Raw: signal at +250 kHz, DC spike at 0'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: freq_tuned
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: 'Tuned: signal at 0, DC spike pushed to -250 kHz'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: lo_shift
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: soi_offset
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: noise_floor
  id: analog_noise_source_x
  parameters:
    amplitude: '0.02'
    seed: '1'
    type: complex
  states: {}
- name: note_dc
  id: note
  parameters:
    note: A direct-conversion receiver leaks its own LO into the mixer, and the result is a constant added to every sample. Turn dc_amp up and a spike grows at 0 Hz
  states: {}
- name: note_tune
  id: note
  parameters:
    note: 'Offset tuning is the fix: park the signal 250 kHz off centre, then shift it back digitally. The DC spike moves with the shift and lands outside the band of interest'
  states: {}
- name: offset_tune
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: soi_offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 150e3, 50e3)
    type: ccf
  states: {}
- name: shift_up
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: soi_noise
  id: analog_noise_source_x
  parameters:
    amplitude: '0.5'
    seed: '0'
    type: complex
  states: {}
- name: soi_shape
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [add, '0', dc_offset, '0']
- [dc_offset, '0', throttle, '0']
- [lo_shift, '0', shift_up, '1']
- [noise_floor, '0', add, '1']
- [offset_tune, '0', freq_tuned, '0']
- [shift_up, '0', add, '0']
- [soi_noise, '0', soi_shape, '0']
- [soi_shape, '0', shift_up, '0']
- [throttle, '0', freq_raw, '0']
- [throttle, '0', offset_tune, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
