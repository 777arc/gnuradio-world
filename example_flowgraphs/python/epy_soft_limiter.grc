options:
  parameters:
    author: Claude
    description: Arbitrary Python DSP in the browser -- a soft limiter written as an Embedded Python Block, with its gain driven live by a slider
    generate_options: qt_gui
    id: Python_Block___Soft_Limiter
    title: Python Block - Soft Limiter
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Limiter gain
    min_len: '240'
    start: '0.1'
    step: '0.1'
    stop: '20'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: scope
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: limited
    name: Soft limiter output
    samp_rate: '32000'
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: soft_limiter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: a soft limiter.

      The gain below is driven live by the QT GUI Range control in this flowgraph, so
      raising the slider past 1.0 turns the sine into a flat-topped, clipped wave --
      a shape no stock GNU Radio block produces.

      Edit this code in the block's Properties dialog, press the button under it to
      re-read it, and the block's parameters and ports follow whatever you wrote.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Soft limiter: y = tanh(gain * x)"""

          def __init__(self, gain=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Soft Limiter',
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.gain = gain

          def work(self, input_items, output_items):
              np.tanh(self.gain * input_items[0], out=output_items[0])
              return len(output_items[0])
    gain: gain
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate
    type: float
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1000'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [soft_limiter, '0', scope, '0']
- [throttle, '0', soft_limiter, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
