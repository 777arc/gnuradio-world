options:
  parameters:
    description: Every QT GUI control widget in one flowgraph. The Numeric Entry retunes the tone and the Dial rides its level; the rest publish their state as messages, which the console pane prints. Each state control announces itself once when the flowgraph starts, so what the widgets show and what the graph believes agree before anything is touched.
    generate_options: qt_gui
    id: control_widgets
    output_language: python
    title: QT GUI Control Widgets
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tone
  id: variable_qtgui_numeric_entry
  parameters:
    description: The tone the signal chain generates.
    enabled: 'True'
    increment: '100'
    label: Tone
    precision: '10'
    unit: Hz
    value: '1000'
    value_max: '4000'
    value_min: '100'
  states: {}
- name: readout
  id: variable_qtgui_label
  parameters:
    label: Tone now
    type: real
    value: tone
  states: {}
- name: level
  id: variable_qtgui_dial_control
  parameters:
    label: Level
    maximum: '10'
    minimum: '0'
    outputmsgname: level
    scaleFactor: '0.1'
    showvalue: 'True'
    type: real
    value: '0.8'
  states: {}
- name: mode
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'True'
    label: Mode
    outputmsgname: mode
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: burst
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Burst
    outputmsgname: burst
    pressBackgroundColor: green
    pressFontColor: black
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: mute
  id: variable_qtgui_msgcheckbox
  parameters:
    initPressed: 'False'
    label: Mute
    outputmsgname: mute
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: ping
  id: variable_qtgui_msg_push_button
  parameters:
    label: Ping
    msgName: ping
    type: int
    value: '1'
  states: {}
- name: radio
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Receive frequency
    maxFreqHz: '1700'
    minFreqHz: '30'
    value: '100'
  states: {}
- name: note
  id: qtgui_edit_box_msg
  parameters:
    key: note
    label: Note
    type: string
    value: hello
  states: {}
- name: source
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: gain
  id: blocks_multiply_const_xx
  parameters:
    constant: level
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: scope
  id: qtgui_time_sink_x
  parameters:
    name: Tone
    samp_rate: samp_rate
    size: '1024'
    type: complex
    ymax: '2'
    ymin: '-2'
    yunit: ''
  states: {}
- name: message_debug
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [source, '0', gain, '0']
- [gain, '0', throttle, '0']
- [throttle, '0', scope, '0']
- {src_blk_id: level, src_port_id: value, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: mode, src_port_id: state, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: burst, src_port_id: state, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: mute, src_port_id: state, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: ping, src_port_id: pressed, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: radio, src_port_id: valueout, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: note, src_port_id: msg, snk_blk_id: message_debug, snk_port_id: print}

metadata:
  file_format: 1
  grc_version: 3.10.9.2
