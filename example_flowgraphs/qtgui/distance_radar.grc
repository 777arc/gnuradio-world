options:
  parameters:
    description: Adapted from GNU Radio's own example (gr-qtgui/examples/test_distanceradar.grc).
    generate_options: qt_gui
    id: test_distanceradar
    output_language: python
    title: Distance Radar Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: variable_qtgui_distanceradar_0
  id: variable_qtgui_distanceradar
  parameters:
    label: Radius
    ticklabels: '[''20'', ''40'', ''60'', ''80'', ''100'']'
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 0,0,1,1
    label: 25%
    msgName: radius
    type: int
    value: '25'
  states: {}
- name: variable_qtgui_msg_push_button_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 1,0,1,1
    label: 50%
    msgName: radius
    type: int
    value: '50'
  states: {}
- name: variable_qtgui_msg_push_button_0_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 2,0,1,1
    label: 75%
    msgName: radius
    type: int
    value: '75'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, variable_qtgui_distanceradar_0, radius]
- [variable_qtgui_msg_push_button_0_0, pressed, variable_qtgui_distanceradar_0, radius]
- [variable_qtgui_msg_push_button_0_0_0, pressed, variable_qtgui_distanceradar_0, radius]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
