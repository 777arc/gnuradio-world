options:
  parameters:
    author: GNU Radio World
    description: A browser-native frequency-only spectrum analyzer with manual and peak-tracking markers, trace averaging and max hold, and a 99% occupied-bandwidth measurement.
    generate_options: qt_gui
    id: Spectrum_Analyzer
    title: Browser-Native Spectrum Analyzer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analyzer
  id: wasm_spectrum_analyzer_sink
  parameters:
    average: '0.2'
    center_freq: '0'
    db_per_div: '10'
    fftsize: '4096'
    level_offset_db: '0'
    level_unit: dBFS
    name: Spectrum Analyzer
    obw_percent: '99'
    obw_span: '100000'
    peak_track: 'True'
    reference_level: '0'
    samp_rate: samp_rate
    trace_mode: average
    type: complex
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"analyzer":[0,0,12,7]}'
    row_height: '60'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '125000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [throttle, '0', analyzer, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
