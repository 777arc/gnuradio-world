options:
  parameters:
    description: QT GUI Sink is the spectrum, waterfall, time and constellation plots in one tabbed widget rather than four blocks, which is the quickest way to look at an unfamiliar signal. Here it watches a noisy tone; the tabs along the top switch views and the whole widget shares one FFT.
    generate_options: qt_gui
    id: combined_sink
    output_language: python
    title: QT GUI Sink (all four plots)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: samp_rate
    waveform: analog.GR_COS_WAVE
    frequency: '20000'
    amplitude: '0.7'
    offset: '0'
    phase: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amplitude: '0.05'
    seed: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
    limit: time
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    type: complex
    name: '"Noisy tone"'
    fftsize: '1024'
    fc: '0'
    bw: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
