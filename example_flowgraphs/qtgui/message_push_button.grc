options:
  parameters:
    description: Adapted from GNU Radio's own example (gr-qtgui/examples/test_msgpush.grc).
    generate_options: qt_gui
    id: test_msgpush
    output_language: python
    title: Message Push Button Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: state
  id: variable_qtgui_msg_push_button
  parameters:
    label: state
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [state, pressed, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
