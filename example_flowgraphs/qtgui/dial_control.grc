options:
  parameters:
    description: Adapted from GNU Radio's own example (gr-qtgui/examples/test_dialcontrol.grc).
    generate_options: qt_gui
    id: test_dial
    output_language: python
    title: Dial Control Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: Freq
    type: int
    value: volume
  states: {}
- name: volume
  id: variable_qtgui_dial_control
  parameters:
    maximum: '100'
    minimum: '0'
    showvalue: 'False'
    type: int
    value: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [volume, value, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
