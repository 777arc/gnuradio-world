options:
  parameters:
    description: Three of gr-qtgui's sinks looking at one BPSK signal. The Histogram Sink bins the noisy symbols, two humps at +/-1 whose overlap is the error rate; the Eye Sink folds the pulse-shaped version of the same stream at the symbol rate, so the opening of the eye is that margin seen in time; and the Time Raster Sink draws the bits themselves, one row of 32 at a time.
    generate_options: qt_gui
    id: eye_histogram_raster
    output_language: python
    title: QT GUI Eye, Histogram and Time Raster Sinks
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '2'
    num_samps: '10000'
    repeat: 'True'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    type: byte
    samples_per_second: samp_rate/sps
    limit: time
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '-1'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    type: fff
    interp: sps
    taps: firdes.root_raised_cosine(sps, samp_rate, samp_rate/sps, 0.35, 11*sps)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    type: float
    noise_type: analog.GR_GAUSSIAN
    amplitude: '0.15'
    seed: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    type: float
    name: '"Eye diagram"'
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    ymin: '-1.6'
    ymax: '1.6'
    grid: 'True'
    entags: 'False'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    type: float
    name: '"Sample distribution"'
    size: '2048'
    bins: '81'
    xmin: '-2'
    xmax: '2'
    grid: 'True'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    type: byte
    name: '"Symbols"'
    samp_rate: samp_rate/sps
    nrows: '32'
    ncols: '32'
    zmin: '0'
    x_label: '"Bit"'
    y_label: '"Row"'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_eye_sink_x_0, '0']

metadata:
  file_format: 1
