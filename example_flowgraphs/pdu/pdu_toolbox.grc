options:
  parameters:
    author: Marc
    description: Every gr-pdu utility in one graph. Random PDUs are stamped with the system time, labelled, filtered on that label, measured for latency, stripped of the timestamp and split into metadata and payload; alongside, Tags To PDU frames a byte stream between its SOB and EOB tags.
    generate_options: qt_gui
    id: PDU_Toolbox
    title: PDU Toolbox
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: byte_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '64'
    type: byte
  states: {}
- name: drop_time
  id: pdu_pdu_remove
  parameters:
    k: pmt.intern("system_time")
  states: {}
- name: eob
  id: variable_tag_object
  parameters:
    key: pmt.intern("EOB")
    offset: '12'
    src: pmt.intern("tagged_bytes")
    value: pmt.PMT_T
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: keep_labelled
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("label")
    v: pmt.intern("random")
  states: {}
- name: label
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("label")
    v: pmt.intern("random")
  states: {}
- name: latency
  id: pdu_time_delta
  parameters:
    delta_key: pmt.intern("time_delta_ms")
    time_key: pmt.intern("system_time")
  states: {}
- name: metadata
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: payload
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: random_pdu
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '255'
    maxsize: '16'
    minsize: '8'
  states: {}
- name: sob
  id: variable_tag_object
  parameters:
    key: pmt.intern("SOB")
    offset: '0'
    src: pmt.intern("tagged_bytes")
    value: pmt.PMT_T
  states: {}
- name: split
  id: pdu_pdu_split
  parameters:
    pass_empty: 'False'
  states: {}
- name: stamp_time
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("system_time")
  states: {}
- name: tagged_bytes
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[sob, eob]'
    type: byte
    vector: list(range(1, 33))
  states: {}
- name: tags_to_pdu
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: EOB
    rate: '64'
    start_tag: SOB
    start_time: '0'
    type: b
  states: {}
- name: trigger
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("generate")
    period: '500'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [byte_throttle, '0', tags_to_pdu, '0']
- {src_blk_id: drop_time, src_port_id: pdus, snk_blk_id: split, snk_port_id: pdu}
- {src_blk_id: keep_labelled, src_port_id: pdus, snk_blk_id: latency, snk_port_id: pdu}
- {src_blk_id: label, src_port_id: pdus, snk_blk_id: keep_labelled, snk_port_id: pdus}
- {src_blk_id: latency, src_port_id: pdu, snk_blk_id: drop_time, snk_port_id: pdus}
- {src_blk_id: random_pdu, src_port_id: pdus, snk_blk_id: stamp_time, snk_port_id: pdu}
- {src_blk_id: split, src_port_id: dict, snk_blk_id: metadata, snk_port_id: print}
- {src_blk_id: split, src_port_id: vec, snk_blk_id: payload, snk_port_id: print}
- {src_blk_id: stamp_time, src_port_id: pdu, snk_blk_id: label, snk_port_id: pdus}
- [tagged_bytes, '0', byte_throttle, '0']
- {src_blk_id: tags_to_pdu, src_port_id: pdus, snk_blk_id: frames, snk_port_id: print}
- {src_blk_id: trigger, src_port_id: strobe, snk_blk_id: random_pdu, snk_port_id: generate}

metadata:
  file_format: 2
  grc_version: 3.11.0.0
