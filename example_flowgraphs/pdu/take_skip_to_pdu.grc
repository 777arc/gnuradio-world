options:
  parameters:
    author: Marc
    description: Cuts a stream into PDUs of Take samples, dropping Skip samples between them, then turns the PDUs back into a stream to see the bursts. Both counts are live controls; Message Debug prints each PDU's pdu_num.
    generate_options: qt_gui
    id: Bursts_with_Take_Skip_To_PDU
    title: Bursts with Take/Skip To PDU
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: skip
  id: variable_qtgui_range
  parameters:
    label: Skip (samples between PDUs)
    min_len: '240'
    rangeType: int
    start: '0'
    step: '64'
    stop: '4096'
    value: '768'
  states: {}
- name: take
  id: variable_qtgui_range
  parameters:
    label: Take (samples per PDU)
    min_len: '240'
    rangeType: int
    start: '16'
    step: '16'
    stop: '1024'
    value: '256'
  states: {}
- name: bursts
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: 'PDUs as a stream: the kept samples, then silence for the skipped ones'
    size: '4096'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: input
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: Input tone
    size: '4096'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: pdu_metadata
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: pdu_to_stream
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: float
  states: {}
- name: take_skip_to_pdu
  id: pdu_take_skip_to_pdu
  parameters:
    skip: skip
    take: take
    type: float
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '250'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [pdu_to_stream, '0', bursts, '0']
- {src_blk_id: take_skip_to_pdu, src_port_id: pdus, snk_blk_id: pdu_metadata, snk_port_id: print}
- {src_blk_id: take_skip_to_pdu, src_port_id: pdus, snk_blk_id: pdu_to_stream, snk_port_id: pdus}
- [throttle, '0', input, '0']
- [throttle, '0', take_skip_to_pdu, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
