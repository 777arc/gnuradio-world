options:
  parameters:
    author: Marc
    description: Receive and display spectrum from an ADALM-PLUTO using stock firmware.
    generate_options: qt_gui
    id: PlutoSDR_Receive_Example
    title: PlutoSDR Receive Example
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: '70000000'
    step: '1000000'
    stop: '6000000000'
    value: '100000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '65'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["2.4 MHz", "2.5 MHz", "3.2 MHz", "3.84 MHz", "4 MHz", "5 MHz", "6 MHz", "7.68 MHz", "8 MHz", "10 MHz", "12 MHz", "15.36 MHz", "16 MHz", "20 MHz", "24 MHz", "25 MHz", "30.72 MHz", "32 MHz", "40 MHz", "50 MHz", "56 MHz"]'
    options: '[2400000, 2500000, 3200000, 3840000, 4000000, 5000000, 6000000, 7680000, 8000000, 10000000, 12000000, 15360000, 16000000, 20000000, 24000000, 25000000, 30720000, 32000000, 40000000, 50000000, 56000000]'
    value: '2500000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    average: '0.1'
    fc: center_freq
    fftsize: '2048'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    samp_rate: samp_rate
    update_time: '0.1'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"center_freq":[0,0,5,1],"rx_gain":[5,0,4,1],"samp_rate":[9,0,3,1],"qtgui_freq_sink_x_0":[0,1,12,3],"qtgui_waterfall_sink_x_0":[0,4,12,6]}'
    row_height: '60'
  states: {}
- name: wasm_plutosdr_source_0
  id: wasm_plutosdr_source
  parameters:
    bandwidth: samp_rate
    bb_dc: 'True'
    buffer_size: '32768'
    center_freq: center_freq
    channels: '1'
    device: ''
    gain1: rx_gain
    gain2: '30'
    gain_mode1: manual
    gain_mode2: slow_attack
    quadrature: 'True'
    rf_dc: 'True'
    samp_rate: samp_rate
  states: {}

connections:
- [wasm_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [wasm_plutosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
