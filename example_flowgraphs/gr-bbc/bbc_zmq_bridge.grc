options:
  parameters:
    author: James Morrison
    description: Browser adaptation of the upstream ZeroMQ bridge. A browser tab cannot open ZeroMQ sockets, so an in-page vector source and Message Debug demonstrate the same codeword-in/message-out boundary.
    generate_options: no_gui
    id: bbc_zmq_bridge
    output_language: python
    run_options: run
    title: BBC ZeroMQ Bridge (Browser Adaptation)
  states: {}

blocks:
- name: CHECKSUM_BITS
  id: variable
  parameters:
    comment: Check bits appended to each message; must match at both ends.
    value: '32'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: Codeword size in bytes. A larger ratio survives more jamming.
    value: '8192'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: Message size in bytes.
    value: '32'
  states: {}
- name: message
  id: variable
  parameters:
    comment: In-page stand-in for the upstream ZeroMQ codeword producer.
    value: '[66, 66, 67, 32, 115, 97, 121, 115, 32, 104, 101, 108, 108, 111, 32, 116, 111, 32, 71, 82, 67, 111, 110, 50, 54, 33, 0, 0, 0, 0, 0, 0]'
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    max_candidates: '256'
    max_steps: '5000000'
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: In-page stand-in for the upstream ZeroMQ message consumer.
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: The same messages also come out as a byte-vector stream.
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: message
    vlen: MESSAGE_LENGTH
  states: {}

connections:
- [bbc_bbc_decoder_0, '0', blocks_null_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]
- [bbc_bbc_encoder_0, '0', bbc_bbc_decoder_0, '0']
- [blocks_vector_source_x_0, '0', bbc_bbc_encoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
