options:
  parameters:
    author: James Morrison
    description: Browser adaptation of the upstream ZeroMQ bridge. A browser tab cannot open ZeroMQ sockets, so an in-page vector source and Message Debug demonstrate the same codeword-in/message-out boundary.
    generate_options: no_gui
    id: bbc_zmq_bridge
    output_language: python
    run_options: run
    title: BBC ZeroMQ Bridge (Browser Adaptation)
  states: {}

blocks:
- name: CHECKSUM_BITS
  id: variable
  parameters:
    comment: Check bits appended to each message; must match at both ends.
    value: '32'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: Codeword size in bytes. A larger ratio survives more jamming.
    value: '8192'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: Message size in bytes.
    value: '32'
  states: {}
- name: message
  id: variable
  parameters:
    comment: In-page stand-in for the upstream ZeroMQ codeword producer; hex bytes match Message Debug's display.
    value: '[0x42, 0x42, 0x43, 0x20, 0x73, 0x61, 0x79, 0x73, 0x20, 0x68, 0x65, 0x6c, 0x6c, 0x6f, 0x20, 0x74, 0x6f, 0x20, 0x47, 0x52, 0x43, 0x6f, 0x6e, 0x32, 0x36, 0x21, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00]'
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    max_candidates: '256'
    max_steps: '5000000'
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: In-page stand-in for the upstream ZeroMQ message consumer.
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: The same messages also come out as a byte-vector stream.
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: message
    vlen: MESSAGE_LENGTH
  states: {}

connections:
- [bbc_bbc_decoder_0, '0', blocks_null_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]
- [bbc_bbc_encoder_0, '0', bbc_bbc_decoder_0, '0']
- [blocks_vector_source_x_0, '0', bbc_bbc_encoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
