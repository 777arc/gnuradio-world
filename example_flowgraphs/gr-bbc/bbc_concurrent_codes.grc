options:
  parameters:
    author: James Morrison
    description: Two messages OR'd into one codeword, both recovered.
    generate_options: no_gui
    id: bbc_concurrent_codes
    output_language: python
    run_options: run
    title: BBC Concurrent Codes
  states: {}

blocks:
- name: CHECKSUM_BITS
  id: variable
  parameters:
    value: '32'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    value: '16'
  states: {}
- name: message1
  id: variable
  parameters:
    value: '[102, 105, 114, 115, 116, 32, 115, 101, 110, 100, 101, 114, 46, 46, 46, 0]'
  states: {}
- name: message2
  id: variable
  parameters:
    value: '[115, 101, 99, 111, 110, 100, 32, 115, 101, 110, 100, 101, 114, 46, 46, 0]'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: message1
    vlen: MESSAGE_LENGTH
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: message2
    vlen: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_1
  id: bbc_bbc_encoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    comment: Both senders share one codeword. Marks are only ever added, so neither message is destroyed.
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    comment: Emits both messages.
    max_candidates: '256'
    max_steps: '5000000'
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}

connections:
- [bbc_bbc_decoder_0, '0', blocks_null_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]
- [bbc_bbc_encoder_0, '0', blocks_vector_to_stream_0, '0']
- [bbc_bbc_encoder_1, '0', blocks_vector_to_stream_1, '0']
- [blocks_or_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', bbc_bbc_decoder_0, '0']
- [blocks_vector_source_x_0, '0', bbc_bbc_encoder_0, '0']
- [blocks_vector_source_x_1, '0', bbc_bbc_encoder_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_or_xx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_or_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
