options:
  parameters:
    author: James Morrison
    description: A jam-resistant BBC control channel that commands a frequency hop.
    generate_options: qt_gui
    id: bbc_fhss_control
    output_language: python
    title: BBC Frequency Hop Control
  states: {}

blocks:
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    value: '8'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: CHECKSUM_BITS
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    comment: Control channel, as a baseband offset.
    value: 20e3
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: The payload signal that gets hopped.
    value: 5e3
  states: {}
- name: jam_amplitude
  id: variable
  parameters:
    comment: Jammer power relative to the control channel.
    value: '1.0'
  states: {}
- name: jam_bytes
  id: variable
  parameters:
    value: '[0x0d, 0xb4, 0x5b, 0x02] * 1024'
  states: {}
- name: commands
  id: variable
  parameters:
    comment: Two hop commands in hex, matching Message Debug's display; sent in turn.
    value: '[0x2b, 0x32, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00, 0x2d, 0x32, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00]'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: commands
    vlen: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    message_length: MESSAGE_LENGTH
    codeword_length: CODEWORD_LENGTH
    checksum_length: CHECKSUM_BITS
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_OOKModulator_0
  id: bbc_OOKModulator
  parameters:
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: Jammer payload
    repeat: 'True'
    type: byte
    vector: jam_bytes
  states: {}
- name: bbc_OOKModulator_1
  id: bbc_OOKModulator
  parameters:
    comment: Jammer on the control channel
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: jam_amplitude
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Marks are added, never removed.
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Keeps the waterfall running in real time.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: bbc_OOKDemodulator_0
  id: bbc_OOKDemodulator
  parameters:
    bandwidth: '0'
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
    threshold: '0.25'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    message_length: MESSAGE_LENGTH
    codeword_length: CODEWORD_LENGTH
    checksum_length: CHECKSUM_BITS
    max_candidates: '256'
    max_steps: '5000000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: wasm_bbc_frequency_command_0
  id: wasm_bbc_frequency_command
  parameters:
    comment: Decoded message to hop command; browser-native replacement for the upstream Embedded Python adapter.
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    comment: The signal being hopped.
    amp: '1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    comment: Hops when the control channel says so.
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Hopping signal"'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', bbc_bbc_encoder_0, '0']
- [bbc_bbc_encoder_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', bbc_OOKModulator_0, '0']
- [bbc_OOKModulator_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_1, '0', bbc_OOKModulator_1, '0']
- [bbc_OOKModulator_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', bbc_OOKDemodulator_0, '0']
- [bbc_OOKDemodulator_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', bbc_bbc_decoder_0, '0']
- [bbc_bbc_decoder_0, '0', blocks_null_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]
- [bbc_bbc_decoder_0, decoded, wasm_bbc_frequency_command_0, decoded]
- [wasm_bbc_frequency_command_0, freq, freq_xlating_fir_filter_xxx_0, freq]
- [analog_sig_source_x_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
