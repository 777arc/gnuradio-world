options:
  parameters:
    author: James Morrison
    description: BBC over OOK, recovered while a stronger jammer floods the channel with marks.
    generate_options: no_gui
    id: bbc_ook_jammed
    output_language: python
    run_options: run
    title: BBC over OOK with a Jammer
  states: {}

blocks:
- name: CHECKSUM_BITS
  id: variable
  parameters:
    value: '32'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: 128x expansion over the message.
    value: '1024'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    value: '8'
  states: {}
- name: NUM_CODEWORDS
  id: variable
  parameters:
    comment: The demodulator drops the filter warm-up, so the last codeword is always short. Send a few.
    value: '3'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    comment: Baseband offset, not an RF frequency.
    value: 20e3
  states: {}
- name: jam_amplitude
  id: variable
  parameters:
    comment: 1.0 means the jammer is as strong as the signal. Try turning it up.
    value: '1.0'
  states: {}
- name: jam_bytes
  id: variable
  parameters:
    comment: Pseudo-random keying, so the jammer sprays marks across the codeword.
    value: '[0x0d, 0xb4, 0x5b, 0x02] * 1024'
  states: {}
- name: message
  id: variable
  parameters:
    comment: Hex bytes, matching Message Debug's display.
    value: '[0x47, 0x52, 0x43, 0x6f, 0x6e, 0x32, 0x36, 0x21]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: message
    vlen: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: NUM_CODEWORDS
    type: byte
    vlen: CODEWORD_LENGTH
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_OOKModulator_0
  id: bbc_OOKModulator
  parameters:
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: Jammer payload
    repeat: 'True'
    type: byte
    vector: jam_bytes
  states: {}
- name: bbc_OOKModulator_1
  id: bbc_OOKModulator
  parameters:
    carrier_freq: carrier_freq
    comment: Jammer, same channel
    samp_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: jam_amplitude
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: The Z channel - a jammer can add marks but never remove them.
    type: complex
  states: {}
- name: bbc_OOKDemodulator_0
  id: bbc_OOKDemodulator
  parameters:
    bandwidth: '0'
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
    threshold: '0.25'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    checksum_length: CHECKSUM_BITS
    codeword_length: CODEWORD_LENGTH
    max_candidates: '256'
    max_steps: '5000000'
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}

connections:
- [bbc_OOKDemodulator_0, '0', blocks_stream_to_vector_0, '0']
- [bbc_OOKModulator_0, '0', blocks_add_xx_0, '0']
- [bbc_OOKModulator_1, '0', blocks_multiply_const_vxx_0, '0']
- [bbc_bbc_decoder_0, '0', blocks_null_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]
- [bbc_bbc_encoder_0, '0', blocks_head_0, '0']
- [blocks_add_xx_0, '0', bbc_OOKDemodulator_0, '0']
- [blocks_head_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_stream_to_vector_0, '0', bbc_bbc_decoder_0, '0']
- [blocks_vector_source_x_0, '0', bbc_bbc_encoder_0, '0']
- [blocks_vector_source_x_1, '0', bbc_OOKModulator_1, '0']
- [blocks_vector_to_stream_0, '0', bbc_OOKModulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
