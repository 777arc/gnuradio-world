options:
  parameters:
    author: Bastian Bloessl
    description: Maps all four QPSK symbol pairs to phase and recovers their I/Q values with gr-ieee802-15-4.
    generate_options: qt_gui
    id: IEEE_802_15_4_QPSK_Phase_Loopback
    title: IEEE 802.15.4 QPSK Phase Loopback
  states: {}

blocks:
- name: symbol_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: explanation
  id: note
  parameters:
    note: The mapper converts every I/Q pair to a phase in radians; the demapper recovers the original -1/+1 streams.
  states: {}
- name: i_symbols
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: '[-1, -1, 1, 1]'
  states: {}
- name: pace
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: symbol_rate
    type: float
  states: {}
- name: phase_and_symbols
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    alpha3: '1'
    grid: 'True'
    label1: Phase (radians)
    label2: Recovered I
    label3: Recovered Q
    name: QPSK phase and recovered symbols
    nconnections: '3'
    samp_rate: symbol_rate
    size: '256'
    stemplot: 'True'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ylabel: Value
    ymax: '3.5'
    ymin: '-3.5'
    yunit: ''
  states: {}
- name: phase_demapper
  id: ieee802_15_4_qpsk_demapper_fi
  parameters: {}
  states: {}
- name: phase_mapper
  id: ieee802_15_4_qpsk_mapper_if
  parameters: {}
  states: {}
- name: q_symbols
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: '[-1, 1, -1, 1]'
  states: {}
- name: recovered_i
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: recovered_q
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [i_symbols, '0', phase_mapper, '0']
- [pace, '0', phase_and_symbols, '0']
- [pace, '0', phase_demapper, '0']
- [phase_demapper, '0', recovered_i, '0']
- [phase_demapper, '1', recovered_q, '0']
- [phase_mapper, '0', pace, '0']
- [q_symbols, '0', phase_mapper, '1']
- [recovered_i, '0', phase_and_symbols, '1']
- [recovered_q, '0', phase_and_symbols, '2']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
