options:
  parameters:
    author: Bastian Bloessl
    description: Maps bits to CSS codewords and decodes them by minimum distance with gr-ieee802-15-4.
    generate_options: qt_gui
    id: IEEE_802_15_4_CSS_Codeword_Loopback
    title: IEEE 802.15.4 CSS Codeword Loopback
  states: {}

blocks:
- name: chip_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: codewords
  id: variable
  parameters:
    value: '[[0, 1, 0, 1], [1, 0, 1, 0]]'
  states: {}
- name: bits
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 1, 1, 0]'
  states: {}
- name: bits_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: chips_to_float
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: codeword_demapper
  id: ieee802_15_4_codeword_demapper_ib
  parameters:
    bits_per_cw: '1'
    codewords: codewords
  states: {}
- name: codeword_mapper
  id: ieee802_15_4_codeword_mapper_bi
  parameters:
    bits_per_cw: '1'
    codewords: codewords
  states: {}
- name: codeword_scope
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    grid: 'True'
    label1: Mapped chips
    label2: Recovered bit
    name: CSS codeword mapping and recovery
    nconnections: '2'
    samp_rate: chip_rate
    size: '256'
    stemplot: 'True'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ylabel: Chip / bit value
    ymax: '1.2'
    ymin: '-0.2'
    yunit: ''
  states: {}
- name: explanation
  id: note
  parameters:
    note: Each bit selects a four-chip codeword. The minimum-distance demapper recovers the bit, repeated here for an equal-rate plot.
  states: {}
- name: pace
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: chip_rate
    type: int
  states: {}
- name: repeat_recovered_bit
  id: blocks_repeat
  parameters:
    interp: '4'
    type: byte
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [bits, '0', codeword_mapper, '0']
- [bits_to_float, '0', codeword_scope, '1']
- [chips_to_float, '0', codeword_scope, '0']
- [codeword_demapper, '0', repeat_recovered_bit, '0']
- [codeword_mapper, '0', pace, '0']
- [pace, '0', chips_to_float, '0']
- [pace, '0', codeword_demapper, '0']
- [repeat_recovered_bit, '0', bits_to_float, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
