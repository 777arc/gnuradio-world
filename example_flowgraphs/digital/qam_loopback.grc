options:
  parameters:
    author: Marc
    description: Random bytes through QAM Mod, a noisy channel with a frequency offset, and QAM Demod. The constellation sink shows the 16 points after the channel; raise the noise or the offset to watch them smear and the demodulated bits go wrong. The time sink shows the sent bits above the received ones -- slide Align until they line up, since the modem's filters and clock recovery delay the stream.
    generate_options: qt_gui
    id: fg_16_QAM_Modem_Loopback
    title: 16-QAM Modem Loopback
  states: {}

blocks:
- name: align
  id: variable_qtgui_range
  parameters:
    label: Align sent bits to received (bits of delay)
    min_len: '240'
    rangeType: int
    start: '0'
    step: '1'
    stop: '400'
    value: '68'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Channel frequency offset
    min_len: '240'
    start: '-0.01'
    step: '0.0005'
    stop: '0.01'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Channel noise voltage
    min_len: '240'
    start: '0'
    step: '0.005'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bits
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    grid: 'True'
    label1: Received bits
    label2: Sent bits (delayed to line up)
    marker1: '1'
    marker2: '4'
    name: Sent bits vs received bits
    nconnections: '2'
    size: '100'
    srate: samp_rate/sps*4
    style1: '0'
    style2: '0'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.2'
    ymin: '-0.2'
    yunit: ''
  states: {}
- name: bits_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bytes
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: qam_demod
  id: digital_qam_demod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: '0.005'
    mod_code: gray
    phase_bw: '0.0628'
    samples_per_symbol: sps
    timing_bw: '0.0628'
  states: {}
- name: qam_mod
  id: digital_qam_mod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: gray
    samples_per_symbol: sps
  states: {}
- name: received
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    name: 16-QAM after the channel
    size: '1000'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: sent_delay
  id: blocks_delay
  parameters:
    delay: align
    type: byte
  states: {}
- name: sent_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate/sps/2
    type: byte
  states: {}
- name: unpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"align":[3,6,9,1],"bits":[0,0,12,4],"freq_offset":[3,5,9,1],"noise":[3,4,9,1],"received":[0,4,3,4]}'
    row_height: '60'
  states: {}

connections:
- [bits_to_float, '0', bits, '0']
- [bytes, '0', throttle, '0']
- [channel, '0', qam_demod, '0']
- [channel, '0', received, '0']
- [qam_demod, '0', bits_to_float, '0']
- [qam_mod, '0', channel, '0']
- [sent_delay, '0', sent_to_float, '0']
- [sent_to_float, '0', bits, '1']
- [throttle, '0', qam_mod, '0']
- [throttle, '0', unpack, '0']
- [unpack, '0', sent_delay, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
