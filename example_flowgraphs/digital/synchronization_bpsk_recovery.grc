options:
  parameters:
    author: PySDR
    description: Companion to the Synchronization chapter of PySDR
    generate_options: qt_gui
    id: PySDR__BPSK_Timing_and_Frequency_Synchronization
    title: 'PySDR: BPSK Timing and Frequency Synchronization'
  states: {}

blocks:
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency offset (cycles/sample)
    start: '-0.03'
    step: '0.002'
    stop: '0.03'
    value: '0.005'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise voltage
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing offset (epsilon)
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0002'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    npwr: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: bpsk_mod
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.06'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: clock_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '8'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: const_rx
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: '"1. Received (offset + noise)"'
    size: '1024'
    tr_level: '0'
    update_time: '0.1'
  states: {}
- name: const_synced
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: '"3. After Costas loop"'
    size: '1024'
    tr_level: '0'
    update_time: '0.1'
  states: {}
- name: const_timed
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: '"2. After clock recovery"'
    size: '1024'
    tr_level: '0'
    update_time: '0.1'
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {}
- name: note_rx
  id: note
  parameters:
    note: |-
      Receiver: the same steps the chapter writes by hand in Python

      Transmitter: random bits -> BPSK -> RRC pulse shaping

      Channel: noise + carrier frequency offset + sample clock offset

      Try adding more noise or more frequency offset
  states: {}
- name: random_bits
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: time_symbols
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    grid: 'True'
    marker1: '0'
    name: '"Recovered symbols"'
    samp_rate: samp_rate/sps
    size: '256'
    style1: '0'
    tr_level: '0'
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"const_rx":[0,1,4,3],"const_synced":[8,1,4,3],"const_timed":[4,1,4,3],"freq_offset":[0,0,4,1],"noise_volt":[4,0,4,1],"time_offset":[8,0,4,1],"time_symbols":[0,4,12,3]}'
    row_height: '60'
  states: {}

connections:
- [bpsk_mod, '0', channel, '0']
- [channel, '0', throttle, '0']
- [throttle, '0', agc, '0']
- [clock_sync, '0', const_timed, '0']
- [clock_sync, '0', costas, '0']
- [costas, '0', const_synced, '0']
- [costas, '0', time_symbols, '0']
- [random_bits, '0', bpsk_mod, '0']
- [agc, '0', clock_sync, '0']
- [throttle, '0', const_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
