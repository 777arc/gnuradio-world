options:
  parameters:
    category: Custom
    description: Adapted from GNU Radio's own example (gr-digital/examples/burst_shaper.grc). The packet_len tag comes from Stream to Tagged Stream instead of gr.python_to_tag(), and the shaping window is inlined.
    generate_options: no_gui
    id: burst_shaper
    output_language: python
    title: Burst Shaping and PDU Extraction
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: Float
    type: float
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: Complex
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    limit: time
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    ignoretag: 'False'
    limit: time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[complex(1.0), complex(-1.0)]*15'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1.0, -1.0]*15'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '5'
    pre_padding: '5'
    type: float
    window: '[0.0, 0.116978, 0.413176, 0.75, 0.969846, 0.969846, 0.75, 0.413176, 0.116978, 0.0]'
  states: {}
- name: digital_burst_shaper_xx_0_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '5'
    pre_padding: '5'
    type: complex
    window: '[0.0, 0.116978, 0.413176, 0.75, 0.969846, 0.969846, 0.75, 0.413176, 0.116978, 0.0]'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tagger_c
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '30'
    type: complex
  states: {}
- name: tagger_f
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '30'
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle2_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_throttle2_0_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_vector_source_x_0, '0', tagger_c, '0']
- [blocks_vector_source_x_0_0, '0', tagger_f, '0']
- [digital_burst_shaper_xx_0, '0', blocks_throttle2_0, '0']
- [digital_burst_shaper_xx_0_0, '0', blocks_throttle2_0_0, '0']
- {src_blk_id: pdu_tagged_stream_to_pdu_0, src_port_id: pdus, snk_blk_id: blocks_message_debug_0, snk_port_id: print}
- {src_blk_id: pdu_tagged_stream_to_pdu_1, src_port_id: pdus, snk_blk_id: blocks_message_debug_0_0, snk_port_id: print}
- [tagger_c, '0', digital_burst_shaper_xx_0_0, '0']
- [tagger_f, '0', digital_burst_shaper_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
