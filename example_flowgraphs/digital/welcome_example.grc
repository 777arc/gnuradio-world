options:
  parameters:
    author: Marc
    description: 8PSK with added noise, adjustable via range widget
    generate_options: qt_gui
    id: PSK_Tx_with_Constellation
    title: PSK Tx with Constellation
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Tone Freq.
    start: '-1*np.pi'
    step: '0.1'
    stop: np.pi
    value: 2*np.pi*50e3/samp_rate
  states: {}
- name: mag
  id: variable_qtgui_range
  parameters:
    label: Tone Mag.
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Mag.
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0.3'
    offset: '-0.5'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mag
    mode: vector
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: freq
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '100000'
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    name: Constellation
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    width1: '0'
    xmax: '2.5'
    xmin: '-2.5'
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: mod7
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: note_0
  id: note
  parameters:
    bgcolor: '#4dff58'
    note: |-
      Welcome to GNU Radio World!

      Hit the play button at the top, and
      try changing the sliders
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    name: Scope
    size: '500'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
    yunit: ''
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    name: Waterfall
    type: complex
    update_time: '0.05'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: throttle4
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"constellation":[6,0,3,4],"freq":[9,0,3,1],"mag":[9,2,3,1],"noise":[9,1,3,1],"qtgui_time_sink_x_0":[6,4,6,3],"qtgui_waterfall_sink_x_0":[0,0,6,7]}'
    row_height: '60'
  states: {}
- name: x2
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: x8
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: xx3
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_vco_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', xx3, '2']
- [blocks_rotator_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vco_c_0, '0', blocks_rotator_cc_0, '0']
- [mod7, '0', xx3, '1']
- [throttle4, '0', constellation, '0']
- [throttle4, '0', qtgui_time_sink_x_0, '0']
- [throttle4, '0', qtgui_waterfall_sink_x_0, '0']
- [x2, '0', xx3, '0']
- [x8, '0', mod7, '0']
- [xx3, '0', throttle4, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
