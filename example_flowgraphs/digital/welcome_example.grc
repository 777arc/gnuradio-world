options:
  parameters:
    author: Marc
    description: 8PSK with added noise, adjustable via range widget
    generate_options: qt_gui
    id: PSK_Tx_with_Constellation
    title: PSK Tx with Constellation
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency of Tone
    start: '-90000'
    step: '5000'
    stop: '90000'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Mag of Noise
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: tone_mag
  id: variable_qtgui_range
  parameters:
    label: Mag of Tone
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amplitude: tone_mag
    frequency: freq
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    name: Constellation
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    width1: '0'
  states: {}
- name: mod7
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Welcome to GNU Radio World!
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-90'
  states: {}
- name: throttle4
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"constellation":[0,2,5,4],"freq":[0,0,6,1],"noise":[0,1,12,1],"qtgui_freq_sink_x_1":[5,2,7,4],"tone_mag":[6,0,6,1]}'
    row_height: '60'
  states: {}
- name: x2
  id: analog_noise_source_x
  parameters:
    amplitude: noise
    seed: '0'
    type: complex
  states: {}
- name: x8
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: xx3
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', xx3, '2']
- [mod7, '0', xx3, '1']
- [throttle4, '0', constellation, '0']
- [throttle4, '0', qtgui_freq_sink_x_1, '0']
- [x2, '0', xx3, '0']
- [x8, '0', mod7, '0']
- [xx3, '0', throttle4, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
