options:
  parameters:
    author: PySDR
    description: Companion to the Digital Modulation chapter of PySDR
    generate_options: qt_gui
    id: PySDR__BPSK_vs_QPSK_vs_16_QAM
    title: 'PySDR: BPSK vs QPSK vs 16-QAM'
  states: {}

blocks:
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise voltage (same channel for all three)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    npwr: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: chan_bpsk
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: chan_qam16
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: noise_volt
    seed: '2'
    taps: '[1.0]'
  states: {}
- name: chan_qpsk
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: noise_volt
    seed: '1'
    taps: '[1.0]'
  states: {}
- name: const_bpsk
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: BPSK - 1 bit/symbol
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: const_qam16
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: 16-QAM - 4 bits/symbol
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: const_qpsk
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: QPSK - 2 bits/symbol
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    alpha3: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: BPSK
    label2: QPSK
    label3: 16-QAM
    marker1: '-1'
    marker2: '-1'
    marker3: '-1'
    marker4: '-1'
    marker5: '-1'
    marker6: '-1'
    name: All three occupy the same bandwidth
    nconnections: '3'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    style3: '1'
    style4: '1'
    style5: '1'
    style6: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: mod_bpsk
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: mod_qam16
  id: digital_constellation_modulator
  parameters:
    constellation: qam16
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: mod_qpsk
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: note_noise
  id: note
  parameters:
    note: |-
      Raise the noise and 16-QAM blurs first: its points sit closer together for the same average power, so it buys throughput with noise margin

      One bit per symbol, then two, then four. The same random byte stream feeds all three, through three copies of the same channel
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: 16qam
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: qpsk
  states: {}
- name: random_bits
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: random_bits_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: random_bits_1
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: throttle_bpsk
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: throttle_qam16
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: throttle_qpsk
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"const_bpsk":[0,1,4,4],"const_qam16":[4,1,4,4],"const_qpsk":[8,1,4,4],"freq_sink":[0,5,12,4],"noise_volt":[2,0,8,1]}'
    row_height: '60'
  states: {}

connections:
- [chan_bpsk, '0', throttle_bpsk, '0']
- [chan_qam16, '0', throttle_qam16, '0']
- [chan_qpsk, '0', throttle_qpsk, '0']
- [mod_bpsk, '0', chan_bpsk, '0']
- [mod_qam16, '0', chan_qam16, '0']
- [mod_qpsk, '0', chan_qpsk, '0']
- [random_bits, '0', mod_bpsk, '0']
- [random_bits_0, '0', mod_qpsk, '0']
- [random_bits_1, '0', mod_qam16, '0']
- [throttle_bpsk, '0', const_bpsk, '0']
- [throttle_bpsk, '0', freq_sink, '0']
- [throttle_qam16, '0', const_qam16, '0']
- [throttle_qam16, '0', freq_sink, '2']
- [throttle_qpsk, '0', const_qpsk, '0']
- [throttle_qpsk, '0', freq_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
