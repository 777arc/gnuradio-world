options:
  parameters:
    author: PySDR
    description: Companion to the Digital Modulation chapter of PySDR
    generate_options: qt_gui
    id: PySDR__4_FSK_and_Frequency_Spacing
    title: 'PySDR: 4-FSK and Frequency Spacing'
  states: {}

blocks:
- name: delta_f
  id: variable_qtgui_range
  parameters:
    label: Frequency spacing, delta f (Hz)
    start: '500'
    step: '500'
    stop: '50000'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: deviation
  id: blocks_multiply_const_xx
  parameters:
    constant: delta_f
    type: float
  states: {}
- name: fm_mod
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: math.pi/samp_rate
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: Four tones, delta f apart
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: hold_symbol
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: note_dev
  id: note
  parameters:
    note: |-
      Random 2-bit symbols map to the four levels -3, -1, 1, 3 and each is held for 100 samples, so the symbol rate is 2 kBd

      Frequency modulating those levels puts four tones on the air, spaced delta f apart. Slide it and watch the tones separate in the spectrum and the waterfall
  states: {}
- name: random_symbols
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: symbol_map
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-3, -1, 1, 3]'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"delta_f":[0,0,12,1],"freq_sink":[0,1,12,3],"waterfall_sink":[0,4,12,3]}'
    row_height: '60'
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-100'
    name: Symbols over time
    samp_rate: samp_rate
    update_time: '0.1'
  states: {}

connections:
- [deviation, '0', fm_mod, '0']
- [fm_mod, '0', throttle, '0']
- [hold_symbol, '0', deviation, '0']
- [random_symbols, '0', symbol_map, '0']
- [symbol_map, '0', hold_symbol, '0']
- [throttle, '0', freq_sink, '0']
- [throttle, '0', waterfall_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
