options:
  parameters:
    author: Marc
    description: 8PSK with added noise, adjustable via range widget
    generate_options: qt_gui
    id: PSK_Tx_with_Constellation
    title: PSK Tx with Constellation
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: mod7
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: throttle4
  id: blocks_throttle2
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}
- name: x2
  id: analog_noise_source_x
  parameters:
    amplitude: noise
    seed: '0'
    type: complex
  states: {}
- name: x8
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: x9
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    name: Constellation
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: xx3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}

connections:
- [mod7, '0', xx3, '0']
- [throttle4, '0', x9, '0']
- [x2, '0', xx3, '1']
- [x8, '0', mod7, '0']
- [xx3, '0', throttle4, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
