options:
  parameters:
    author: Marc
    description: Decodes aircraft from a hosted 1090 MHz ADS-B recording, no radio needed.
    generate_options: qt_gui
    id: ADS_B_from_a_Recording
    title: ADS-B from a Recording
  states: {}

blocks:
- name: rec_rate
  id: variable
  parameters:
    comment: The recording's own complex sample rate
    value: '5000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 2x that, which is what the ADS-B blocks see
    value: '10000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: Noise floor here is about 45, bursts reach 3e6
    label: Detection Threshold
    start: '200'
    step: '100'
    stop: '20000'
    value: '1800'
  states: {}
- name: aircraft_map
  id: wasm_adsb_map_sink
  parameters:
    basemap: light
    comment: Live aircraft state from the decoder; select a row or marker for details
    expire_seconds: '60'
    name: '"Aircraft near the recording site"'
    receiver_latitude: '0'
    receiver_longitude: '0'
    show_labels: 'True'
    show_receiver: 'False'
    stale_seconds: '15'
    trail_seconds: '300'
    units: aviation
    update_time: '0.25'
  states: {}
- name: bursts
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    grid: 'True'
    label1: Burst power
    name: ADS-B bursts
    size: '2048'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ylabel: Power
    ymin: '0'
    yunit: ''
  states: {}
- name: decoded_planes
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: decoder
  id: adsb_decoder
  parameters:
    error_corr: '"Conservative"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: demod
  id: adsb_demod
  parameters:
    fs: samp_rate
  states: {}
- name: framer
  id: adsb_framer
  parameters:
    fs: samp_rate
    threshold: threshold
  states: {}
- name: interp2
  id: blocks_repeat
  parameters:
    comment: 5 Msps is an odd 5 samples/symbol; the ADS-B blocks need an even one
    interp: '2'
    type: float
  states: {}
- name: mag_squared
  id: blocks_complex_to_mag_squared
  parameters:
    comment: The framer works on power, not complex samples
  states: {}
- name: rec
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: ADS-B_20150526_203031Z_1090000kHz_IQ
    repeat: 'True'
    type: short
  states: {}
- name: to_complex
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'False'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- {src_blk_id: decoder, src_port_id: decoded, snk_blk_id: aircraft_map, snk_port_id: decoded}
- {src_blk_id: decoder, src_port_id: decoded, snk_blk_id: decoded_planes, snk_port_id: print}
- [demod, '0', bursts, '0']
- {src_blk_id: demod, src_port_id: demodulated, snk_blk_id: decoder, snk_port_id: demodulated}
- [framer, '0', demod, '0']
- [interp2, '0', framer, '0']
- [mag_squared, '0', interp2, '0']
- [rec, '0', to_complex, '0']
- [to_complex, '0', mag_squared, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
