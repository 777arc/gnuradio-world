options:
  parameters:
    author: Marc
    description: Replays captured Mode S extended squitters through the ADS-B Decoder, no radio needed.
    generate_options: qt_gui
    id: ADS_B_Playback
    title: ADS-B Playback
  states: {}

blocks:
- name: callsign
  id: blocks_message_strobe
  parameters:
    comment: KLM1023 identification (DF 17, TC 4)
    msg: pmt.cons(pmt.dict_add(pmt.dict_add(pmt.make_dict(), pmt.intern("timestamp"), pmt.from_double(1757260800.0)), pmt.intern("snr"), pmt.from_double(21.4)), pmt.init_u8vector(112, [1,0,0,0,1,1,0,1,0,1,0,0,1,0,0,0,0,1,0,0,0,0,0,0,1,1,0,1,0,1,1,0,0,0,1,0,0,0,0,0,0,0,1,0,1,1,0,0,1,1,0,0,0,0,1,1,0,1,1,1,0,0,0,1,1,1,0,0,0,0,1,1,0,0,1,0,1,1,0,0,1,1,1,0,0,0,0,0,0,1,0,1,0,1,1,1,0,1,1,0,0,0,0,0,1,0,0,1,1,0,0,0]))
    period: '2000'
  states: {}
- name: decoded_planes
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: decoder
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: position_even
  id: blocks_message_strobe
  parameters:
    comment: Airborne position, even CPR frame (DF 17, TC 11)
    msg: pmt.cons(pmt.dict_add(pmt.dict_add(pmt.make_dict(), pmt.intern("timestamp"), pmt.from_double(1757260801.0)), pmt.intern("snr"), pmt.from_double(18.9)), pmt.init_u8vector(112, [1,0,0,0,1,1,0,1,0,1,0,0,0,0,0,0,0,1,1,0,0,0,1,0,0,0,0,1,1,1,0,1,0,1,0,1,1,0,0,0,1,1,0,0,0,0,1,1,1,0,0,0,0,0,1,0,1,1,0,1,0,1,1,0,1,0,0,1,0,0,0,0,1,1,0,0,1,0,0,0,1,0,1,0,1,1,0,0,0,0,1,0,1,0,0,0,0,1,1,0,0,0,1,1,1,0,1,0,0,1,1,1]))
    period: '1000'
  states: {}
- name: position_odd
  id: blocks_message_strobe
  parameters:
    comment: Airborne position, odd CPR frame (DF 17, TC 11)
    msg: pmt.cons(pmt.dict_add(pmt.dict_add(pmt.make_dict(), pmt.intern("timestamp"), pmt.from_double(1757260802.0)), pmt.intern("snr"), pmt.from_double(19.6)), pmt.init_u8vector(112, [1,0,0,0,1,1,0,1,0,1,0,0,0,0,0,0,0,1,1,0,0,0,1,0,0,0,0,1,1,1,0,1,0,1,0,1,1,0,0,0,1,1,0,0,0,0,1,1,1,0,0,0,0,1,1,0,0,1,0,0,0,0,1,1,0,1,0,1,1,1,0,0,1,1,0,0,0,1,0,0,0,0,0,1,0,0,1,0,0,1,1,0,1,0,0,1,0,0,1,0,1,0,1,0,1,1,0,1,0,1,1,0]))
    period: '1500'
  states: {}
- name: unknown_messages
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: velocity
  id: blocks_message_strobe
  parameters:
    comment: Airborne velocity (DF 17, TC 19)
    msg: pmt.cons(pmt.dict_add(pmt.dict_add(pmt.make_dict(), pmt.intern("timestamp"), pmt.from_double(1757260803.0)), pmt.intern("snr"), pmt.from_double(17.2)), pmt.init_u8vector(112, [1,0,0,0,1,1,0,1,0,1,0,0,1,0,0,0,0,1,0,1,0,0,0,0,0,0,1,0,0,0,0,0,1,0,0,1,1,0,0,1,0,1,0,0,0,1,0,0,0,0,0,0,1,0,0,1,1,0,0,1,0,1,0,0,0,0,0,0,1,0,0,0,0,0,1,1,1,0,0,0,0,0,0,1,0,1,1,1,0,1,0,1,1,0,1,1,0,0,1,0,1,0,0,0,0,1,0,0,1,1,1,1]))
    period: '3000'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- {src_blk_id: callsign, src_port_id: strobe, snk_blk_id: decoder, snk_port_id: demodulated}
- {src_blk_id: decoder, src_port_id: decoded, snk_blk_id: decoded_planes, snk_port_id: print}
- {src_blk_id: decoder, src_port_id: unknown, snk_blk_id: unknown_messages, snk_port_id: print}
- {src_blk_id: position_even, src_port_id: strobe, snk_blk_id: decoder, snk_port_id: demodulated}
- {src_blk_id: position_odd, src_port_id: strobe, snk_blk_id: decoder, snk_port_id: demodulated}
- {src_blk_id: velocity, src_port_id: strobe, snk_blk_id: decoder, snk_port_id: demodulated}

metadata:
  file_format: 2
  grc_version: 3.11.0.0
