options:
  parameters:
    author: Marc
    description: Receives 1090 MHz ADS-B from an RTL-SDR and decodes the aircraft around you.
    generate_options: qt_gui
    id: ADS_B_Receiver
    title: ADS-B Receiver
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      ADS-B is 1 Msym/s PPM,
      so the rate must be a
      multiple of 1 Msps
    value: '2000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: Raise it until only real bursts trigger
    label: Detection Threshold
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: aircraft_map
  id: wasm_adsb_map_sink
  parameters:
    basemap: light
    comment: Live aircraft state from the decoder; select a row or marker for details
    expire_seconds: '60'
    name: '"Aircraft near the recording site"'
    receiver_latitude: '0'
    receiver_longitude: '0'
    show_labels: 'True'
    show_receiver: 'False'
    stale_seconds: '15'
    trail_seconds: '300'
    units: aviation
    update_time: '0.25'
  states: {}
- name: bursts
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    grid: 'True'
    label1: Burst power
    label2: Threshold
    name: ADS-B bursts
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ylabel: Power
    ymax: '0.5'
    ymin: '0'
    yunit: ''
  states: {}
- name: decoded_planes
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: decoder
  id: adsb_decoder
  parameters:
    error_corr: '"Conservative"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: demod
  id: adsb_demod
  parameters:
    fs: samp_rate
  states: {}
- name: framer
  id: adsb_framer
  parameters:
    fs: samp_rate
    threshold: threshold
  states: {}
- name: mag_squared
  id: blocks_complex_to_mag_squared
  parameters:
    comment: The framer works on power, not complex samples
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Waterfall
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: rtlsdr
  id: wasm_rtlsdr_source
  parameters:
    bias_tee: 'False'
    bufflen: '262144'
    center_freq: '1090000000'
    device: ''
    direct_samp: '0'
    freq_correction: '0'
    gain: gain
    gain_mode: 'False'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: threshold_trace
  id: analog_const_source_x
  parameters:
    comment: Plots the threshold beside the bursts
    const: threshold
    type: float
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"aircraft_map":[0,1,7,7],"bursts":[7,1,5,3],"gain":[0,0,6,1],"qtgui_waterfall_sink_x_0":[7,4,5,4],"threshold":[6,0,6,1]}'
    row_height: '60'
  states: {}

connections:
- {src_blk_id: decoder, src_port_id: decoded, snk_blk_id: aircraft_map, snk_port_id: decoded}
- {src_blk_id: decoder, src_port_id: decoded, snk_blk_id: decoded_planes, snk_port_id: print}
- [demod, '0', bursts, '0']
- {src_blk_id: demod, src_port_id: demodulated, snk_blk_id: decoder, snk_port_id: demodulated}
- [framer, '0', demod, '0']
- [mag_squared, '0', framer, '0']
- [rtlsdr, '0', mag_squared, '0']
- [rtlsdr, '0', qtgui_waterfall_sink_x_0, '0']
- [threshold_trace, '0', bursts, '1']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
