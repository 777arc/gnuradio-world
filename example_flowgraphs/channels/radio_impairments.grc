options:
  parameters:
    author: Marc
    description: A clean tone through gr-channels' Radio Impairments Model, every knob a live control. IQ imbalance raises an image at the mirror frequency, DC offset a spike at the carrier, the distortion orders put harmonics on the spectrum, and phase noise smears the skirt.
    generate_options: qt_gui
    id: Radio_Impairments_on_a_Tone
    title: Radio Impairments on a Tone
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    label: 3rd-order distortion
    min_len: '240'
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: dc_i
  id: variable_qtgui_range
  parameters:
    label: DC offset I
    min_len: '240'
    start: '-0.5'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: dc_q
  id: variable_qtgui_range
  parameters:
    label: DC offset Q
    min_len: '240'
    start: '-0.5'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency offset (normalized)
    min_len: '240'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: gamma
  id: variable_qtgui_range
  parameters:
    label: 2nd-order distortion
    min_len: '240'
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: magbal
  id: variable_qtgui_range
  parameters:
    label: IQ magnitude imbalance (dB)
    min_len: '240'
    start: '-6'
    step: '0.1'
    stop: '6'
    value: '1'
  states: {}
- name: phase_noise
  id: variable_qtgui_range
  parameters:
    label: Phase noise (dB)
    min_len: '240'
    start: '-60'
    step: '1'
    stop: '0'
    value: '-30'
  states: {}
- name: phasebal
  id: variable_qtgui_range
  parameters:
    label: IQ phase imbalance (deg)
    min_len: '240'
    start: '-30'
    step: '0.5'
    stop: '30'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    name: Impaired tone in the IQ plane
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: impairments
  id: channels_impairments
  parameters:
    beta: beta
    freq_offset: freq_offset
    gamma: gamma
    i_ofs: dc_i
    magbal: magbal
    phase_noise_mag: phase_noise
    phasebal: phasebal
    q_ofs: dc_q
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: 'Impaired tone: image, DC, harmonics and noise skirt'
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymin: '-100'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.7'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [impairments, '0', constellation, '0']
- [impairments, '0', spectrum, '0']
- [throttle, '0', impairments, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
