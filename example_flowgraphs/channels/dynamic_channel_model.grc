options:
  parameters:
    author: Marc
    description: A pure tone through gr-channels' Dynamic Channel Model, a frequency-selective fading channel plus random-walk carrier and sample-rate offsets and AWGN, with the Doppler, CFO step and noise as live controls. Watch the tone wander in the waterfall.
    generate_options: qt_gui
    id: A_Tone_Through_a_Dynamic_Channel
    title: A Tone Through a Dynamic Channel
  states: {}

blocks:
- name: cfo_dev
  id: variable_qtgui_range
  parameters:
    label: CFO random-walk step (Hz)
    min_len: '240'
    start: '0'
    step: '0.5'
    stop: '20'
    value: '1'
  states: {}
- name: doppler
  id: variable_qtgui_range
  parameters:
    label: Max Doppler (Hz)
    min_len: '240'
    start: '0'
    step: '0.5'
    stop: '20'
    value: '2'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise amplitude
    min_len: '240'
    start: '0'
    step: '0.005'
    stop: '0.2'
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: channel
  id: channels_dynamic_channel_model
  parameters:
    K: '4'
    LOS: 'True'
    N: '8'
    cfo_maxdev: '2000'
    cfo_stdev: cfo_dev
    delays: '[0.0, 0.1, 1.3]'
    fD: doppler
    mags: '[1, 0.99, 0.97]'
    noise_amp: noise_amp
    ntaps: '8'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: '100'
    sro_stdev: '0.01'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: After the channel
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymin: '-100'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-100'
    name: Drifting tone
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}

connections:
- [channel, '0', spectrum, '0']
- [channel, '0', waterfall, '0']
- [throttle, '0', channel, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
