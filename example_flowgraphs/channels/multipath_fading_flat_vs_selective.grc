options:
  parameters:
    author: PySDR
    description: Companion to the Multipath Fading chapter of PySDR
    generate_options: qt_gui
    id: PySDR__Flat_vs_Frequency_Selective_Fading
    title: 'PySDR: Flat vs Frequency-Selective Fading'
  states: {}

blocks:
- name: delays
  id: variable
  parameters:
    value: '[0.0, 3.0, 7.0]'
  states: {}
- name: fDTs
  id: variable_qtgui_range
  parameters:
    label: Normalized max Doppler, fD*Ts
    start: '0'
    step: '0.000001'
    stop: '0.00001'
    value: '0.000001'
  states: {}
- name: mags
  id: variable
  parameters:
    value: '[1, 1, 1]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: 'Wideband: notches move across the band'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.02'
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: note_flat
  id: note
  parameters:
    note: 'Slide the bar to emulate the speed of movement in the system.  The wireless channel is emulated using three equal-strength rays at 0, 3 and 7 samples of delay. That spread puts about seven notch periods inside the band, so the spectrum is deeply scalloped rather than flat, showing frequency-selective fading. Raise the Doppler slider and the notches wash out: once the channel decorrelates faster than the sinks average, there is nothing steady left to draw'
  states: {}
- name: selective_fading
  id: channels_selective_fading_model
  parameters:
    K: '4'
    LOS: 'False'
    N: '8'
    delays: delays
    fDTs: fDTs
    mags: mags
    ntaps: '16'
    seed: '0'
  states: {}
- name: throttle_wb
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"fDTs":[3,0,6,1],"freq_sink":[0,1,12,4],"waterfall_sink":[0,5,12,4]}'
    row_height: '60'
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '1024'
    int_max: '-10'
    int_min: '-60'
    name: Notches drifting over time
    samp_rate: samp_rate
    update_time: '0.02'
  states: {}
- name: wideband_src
  id: analog_noise_source_x
  parameters:
    amplitude: '1'
    seed: '0'
    type: complex
  states: {}

connections:
- [selective_fading, '0', freq_sink, '0']
- [selective_fading, '0', waterfall_sink, '0']
- [throttle_wb, '0', selective_fading, '0']
- [wideband_src, '0', throttle_wb, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
