options:
  parameters:
    author: Marcus Müller
    copyright: '2022'
    description: Adapted from GNU Radio's own example (gr-blocks/examples/probe_rate_message_debug.grc).
    generate_options: no_gui
    id: probe_rate_message_debug
    output_language: python
    title: Probe the rate of the Null Source
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    name: Throughput
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_probe_rate_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-191-gf7b9efd3
