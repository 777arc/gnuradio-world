options:
  parameters:
    author: Marc
    description: A flowgraph variable crossing into and out of the message domain. Message Pair to Var moves the frequency slider whenever a message pair (freq . value) arrives -- from the strobe every four seconds, or from the button -- and Variable to Message announces every change of that slider, by hand or by message, as a pair Message Debug prints.
    generate_options: qt_gui
    id: Variables_and_Messages
    title: Variables and Messages
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Tone frequency (Hz)
    min_len: '240'
    start: '100'
    step: '100'
    stop: '8000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: set_500
  id: variable_qtgui_msg_push_button
  parameters:
    label: Set to 500 Hz
    msgName: freq
    type: real
    value: '500'
  states: {}
- name: changes
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: pair_to_var
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: scope
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    name: Tone at the frequency the slider holds
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: strobe_2500
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern("freq"), pmt.from_double(2500))
    period: '4000'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: var_to_msg
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- {src_blk_id: set_500, src_port_id: pressed, snk_blk_id: pair_to_var, snk_port_id: inpair}
- {src_blk_id: strobe_2500, src_port_id: strobe, snk_blk_id: pair_to_var, snk_port_id: inpair}
- [throttle, '0', scope, '0']
- [tone, '0', throttle, '0']
- {src_blk_id: var_to_msg, src_port_id: msgout, snk_blk_id: changes, snk_port_id: print}

metadata:
  file_format: 2
  grc_version: 3.11.0.0
