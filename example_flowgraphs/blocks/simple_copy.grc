options:
  parameters:
    category: Custom
    description: Adapted from GNU Radio's own example (gr-blocks/examples/ctrlport/simple_copy.grc). The Copy block is enabled (upstream toggles it from an external ControlPort script).
    generate_options: qt_gui
    id: simple_copy
    output_language: python
    title: Simple Copy Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
    frequency: '1000'
    amplitude: '0.5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: |-
      Use simple_copy_controller.py
      to enable/disablethis block
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    limit: time
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Make sure to turn on ControlPort (edit ~/.gnuradio/config.conf)
      and run the following script to toggle Copy block:
      cd /src/gnuradio/gr-blocks/examples/ctrlport
      python simple_copy_controller.py 127.0.0.1 <PORT> true
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    legend: 'False'
    size: '1024'
    type: complex
    samp_rate: samp_rate
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', blocks_copy_0, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
