options:
  parameters:
    description: Adapted from GNU Radio's own example (gr-blocks/examples/selector.grc). Reduced to one output so no sink sits idle; input_index still selects between three sources live.
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Selector Demo
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,2)
    start: '0'
    step: '1'
    stop: samp_rate/4
    value: '200'
  states: {}
- name: input_index
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0,1,2)
    rangeType: int
    start: '0'
    step: '1'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
    frequency: freq
    amplitude: '1'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
    frequency: freq
    amplitude: '1'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
    frequency: freq
    amplitude: '1'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |-
      The Selector block passes 
      samples from the input selected
       by input_index to the output 
      selected by output_index.

      Outputs != output_index 
      do not produce samples

      When Enabled is set to Off, 
      no output samples are produced
    enabled: 'True'
    input_index: input_index
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    gui_hint: (0,0,1,1)
    marker1: '1'
    marker2: '1'
    name: '"Output 0"'
    size: '1024'
    type: complex
    samp_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_1, '0', blocks_selector_0, '1']
- [analog_sig_source_x_2, '0', blocks_selector_0, '2']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
