options:
  parameters:
    author: GNU Radio World
    description: Decodes AIS position reports from ships in the hosted 250 kS/s SDRangel recording centered on 162 MHz. Two Frequency Xlating FIR Filters select channel A (161.975 MHz) and channel B (162.025 MHz) at 50 kS/s, gr-ais's AIS Demod recovers the GMSK bits of each, HDLC Deframer checks the CRC of every burst, AIS PDU to NMEA prints the !AIVDM sentences to the console, and the AIS Map plots every vessel on the Thames estuary as its reports arrive. The receive chain is upstream's ais_rx tool, block by block.
    generate_options: qt_gui
    id: AIS_Receiver
    title: AIS Receiver
  states: {}

blocks:
- name: bits_per_sec
  id: variable
  parameters:
    comment: AIS symbol rate
    value: '9600'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Recording center frequency
    value: '162000000'
  states: {}
- name: channel_a_freq
  id: variable
  parameters:
    comment: AIS channel A
    value: '161975000'
  states: {}
- name: channel_b_freq
  id: variable
  parameters:
    comment: AIS channel B
    value: '162025000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    comment: |-
      Per-channel rate after decimation
      (5.2 samples per symbol)
    value: samp_rate/decim
  states: {}
- name: decim
  id: variable
  parameters:
    comment: |-
      Channel filter decimation,
      as ais_rx computes it for 5
      samples per symbol
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Recording sample rate
    value: '250000'
  states: {}
- name: channel_a
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: channel_a_freq - center_freq
    comment: Selects channel A and decimates to 50 kS/s
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 11000, 1000)
    type: ccf
  states: {}
- name: channel_b
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: channel_b_freq - center_freq
    comment: Selects channel B and decimates to 50 kS/s
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 11000, 1000)
    type: ccf
  states: {}
- name: deframer_a
  id: digital_hdlc_deframer_bp
  parameters:
    comment: Unstuffs, checks the CRC, and emits each AIS packet as a PDU
    max: '64'
    min: '11'
  states: {}
- name: deframer_b
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: demod_a
  id: ais_demod
  parameters:
    bits_per_sec: bits_per_sec
    clockrec_gain: '0.01'
    coherent: 'True'
    comment: Frequency sync, AGC, clock recovery and Viterbi GMSK demodulation to NRZI-decoded bits
    fftlen: '1024'
    omega_relative_limit: '0.01'
    samples_per_symbol: channel_rate/bits_per_sec
  states: {}
- name: demod_b
  id: ais_demod
  parameters:
    bits_per_sec: bits_per_sec
    clockrec_gain: '0.01'
    coherent: 'True'
    fftlen: '1024'
    omega_relative_limit: '0.01'
    samples_per_symbol: channel_rate/bits_per_sec
  states: {}
- name: nmea_a
  id: ais_pdu_to_nmea
  parameters:
    comment: Prints each packet as a !AIVDM sentence
    designator: A
  states: {}
- name: nmea_b
  id: ais_pdu_to_nmea
  parameters:
    designator: B
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    comment: |-
      157 s of both AIS channels at
      250 kS/s, centered on 162 MHz
    length: '0'
    offset: '0'
    progress: 'True'
    recording: sdrangel/ais
    repeat: 'True'
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: vessel_map
  id: wasm_ais_map_sink
  parameters:
    basemap: light
    comment: |-
      Both channels' packets,
      decoded and plotted by MMSI;
      select a row or marker for details
    expire_seconds: '1200'
    name: '"Ships on the Thames estuary"'
    receiver_latitude: '0'
    receiver_longitude: '0'
    show_labels: 'True'
    show_receiver: 'False'
    stale_seconds: '180'
    trail_seconds: '1800'
    units: nautical
    update_time: '0.25'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"recording":[0,0,12,1],"waterfall":[0,1,12,3],"vessel_map":[0,4,12,9]}'
    row_height: '60'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: AIS channels A and B
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}

connections:
- [channel_a, '0', demod_a, '0']
- [channel_b, '0', demod_b, '0']
- {src_blk_id: deframer_a, src_port_id: out, snk_blk_id: nmea_a, snk_port_id: print}
- {src_blk_id: deframer_a, src_port_id: out, snk_blk_id: vessel_map, snk_port_id: in}
- {src_blk_id: deframer_b, src_port_id: out, snk_blk_id: nmea_b, snk_port_id: print}
- {src_blk_id: deframer_b, src_port_id: out, snk_blk_id: vessel_map, snk_port_id: in}
- [demod_a, '0', deframer_a, '0']
- [demod_b, '0', deframer_b, '0']
- [recording, '0', throttle, '0']
- [throttle, '0', channel_a, '0']
- [throttle, '0', channel_b, '0']
- [throttle, '0', waterfall, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
