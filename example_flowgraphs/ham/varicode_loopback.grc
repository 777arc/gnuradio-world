options:
  parameters:
    author: Marc
    description: Encodes a message to PSK31 varicode and decodes it straight back.
    generate_options: qt_gui
    id: PSK31_Varicode_Loopback
    title: PSK31 Varicode Loopback
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '31.25'
  states: {}
- name: baud_clock
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: baud_rate
    type: byte
  states: {}
- name: bits
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: Varicode bit
    marker1: '0'
    name: Varicode bit stream
    samp_rate: baud_rate
    size: '128'
    stemplot: 'True'
    style1: '0'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ylabel: Bit
    ymax: '1.2'
    ymin: '-0.2'
    yunit: ''
  states: {}
- name: decoder
  id: ham_varicode_rx
  parameters: {}
  states: {}
- name: encoder
  id: ham_varicode_tx
  parameters: {}
  states: {}
- name: intro
  id: note
  parameters:
    note: Varicode is self-synchronising - "00" ends every character
  states: {}
- name: message
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[67, 81, 32, 67, 81, 32, 67, 81, 32, 100, 101, 32, 86, 69, 51, 88, 89, 90, 32, 32]'
  states: {}
- name: text
  id: wasm_text_sink
  parameters:
    max_line: '40'
    prefix: '"loopback: "'
  states: {}
- name: to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}

connections:
- [baud_clock, '0', decoder, '0']
- [baud_clock, '0', to_float, '0']
- [decoder, '0', text, '0']
- [encoder, '0', baud_clock, '0']
- [message, '0', encoder, '0']
- [to_float, '0', bits, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
