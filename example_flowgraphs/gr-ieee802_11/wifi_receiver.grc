options:
  parameters:
    author: Marc
    description: Decodes IEEE 802.11a frames from a 20 MS/s recording and prints each MAC header.
    generate_options: qt_gui
    id: WiFi_802_11a_Receiver
    title: WiFi 802.11a Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: average_corr
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: average_power
  id: blocks_moving_average_xx
  parameters:
    length: window_size + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: conjugate
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: corr_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: correlate
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: decode_mac
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: delay_ltf
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: delay_stf
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: equalizer
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: samp_rate
    debug: 'False'
    freq: '5320000000'
    log: 'False'
  states: {}
- name: fft
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1.0] * 64'
  states: {}
- name: intro
  id: note
  parameters:
    note: A 20 MS/s recording of 802.11a frames at BPSK 1/2 (6 Mbit/s), about 15 dB SNR. Short training sequence detection, long training sequence alignment, a 64-point FFT and the frame equalizer recover the OFDM symbols; WiFi Decode MAC runs the Viterbi decoder and checks the CRC, and WiFi Parse MAC prints each header to the console below.
  states: {}
- name: normalize
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: parse_mac
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: power
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: wifi_80211a_bpsk12_20M
    repeat: 'True'
    type: complex
  states: {}
- name: sync_long
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: sync_short
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: to_symbols
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '1024'
    int_max: '40'
    int_min: '-40'
    name: '"802.11a bursts"'
    bw: samp_rate
    update_time: '0.1'
  states: {}

connections:
- [average_corr, '0', corr_mag, '0']
- [average_corr, '0', sync_short, '1']
- [average_power, '0', normalize, '1']
- [conjugate, '0', correlate, '1']
- [corr_mag, '0', normalize, '0']
- [correlate, '0', average_corr, '0']
- {src_blk_id: decode_mac, src_port_id: out, snk_blk_id: parse_mac, snk_port_id: in}
- [delay_ltf, '0', sync_long, '1']
- [delay_stf, '0', conjugate, '0']
- [delay_stf, '0', sync_short, '0']
- [equalizer, '0', decode_mac, '0']
- [fft, '0', equalizer, '0']
- [normalize, '0', sync_short, '2']
- [power, '0', average_power, '0']
- [recording, '0', throttle, '0']
- [sync_long, '0', to_symbols, '0']
- [sync_short, '0', delay_ltf, '0']
- [sync_short, '0', sync_long, '0']
- [throttle, '0', correlate, '0']
- [throttle, '0', delay_stf, '0']
- [throttle, '0', power, '0']
- [throttle, '0', waterfall, '0']
- [to_symbols, '0', fft, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
