options:
  parameters:
    author: Marc
    description: Receive and display spectrum from an SDRplay RSP1A over WebUSB.
    generate_options: qt_gui
    id: SDRplay_RSP1A_Receive_Example
    title: SDRplay RSP1A Receive Example
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: '10000'
    step: '100000'
    stop: '2000000000'
    value: '100100000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '102'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"center_freq":[0,0,7,1],"gain":[7,0,5,1],"qtgui_freq_sink_x_0":[0,1,12,3],"qtgui_waterfall_sink_x_0":[0,4,12,6]}'
    row_height: '60'
  states: {}
- name: wasm_sdrplay_rsp1a_source_0
  id: wasm_sdrplay_rsp1a_source
  parameters:
    bandwidth: '0'
    bias_tee: 'False'
    center_freq: center_freq
    dab_notch: 'False'
    device: ''
    fm_notch: 'False'
    gain: gain
    samp_rate: samp_rate
    transfer_size: '16384'
  states: {}

connections:
- [wasm_sdrplay_rsp1a_source_0, '0', qtgui_freq_sink_x_0, '0']
- [wasm_sdrplay_rsp1a_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
