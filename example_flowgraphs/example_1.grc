options:
  parameters:
    author: Marc
    description: test description
    generate_options: qt_gui
    id: Example_flowgraph
    title: Example flowgraph
  states: {}

blocks:
- name: throttle4
  id: blocks_throttle2
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: x1
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '2000'
    samp_rate: '32000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: x2
  id: analog_noise_source_x
  parameters:
    amplitude: '1'
    seed: '0'
    type: complex
  states: {}
- name: x5
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    marker1: '0'
    name: Scope
    samp_rate: '32000'
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    yunit: ''
  states: {}
- name: xx3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}

connections:
- [throttle4, '0', x5, '0']
- [x1, '0', xx3, '0']
- [x2, '0', xx3, '1']
- [xx3, '0', throttle4, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
