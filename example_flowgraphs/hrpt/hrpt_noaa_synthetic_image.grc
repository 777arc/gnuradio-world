options:
  parameters:
    author: gnuradio-world
    description: 32 synthetic NOAA HRPT minor frames (32 AVHRR scan lines, carrying this repo's own logo on channel 2) that exercise the real noaa_hrpt_deframer and hrpt_image_sink blocks end to end. See example_flowgraphs/hrpt/README.md for how the fixture was generated and why the PLL/bit-slicer stage is skipped here.
    generate_options: qt_gui
    id: hrpt_noaa_synthetic_image
    title: HRPT NOAA Synthetic Image
  states: {}

blocks:
- name: src
  id: blocks_file_source
  parameters:
    file: https://raw.githubusercontent.com/777arc/gnuradio-world/main/example_flowgraphs/hrpt/noaa_synthetic_symbols.bin
    type: byte
    repeat: 'False'
  states: {}
- name: deframe
  id: noaa_hrpt_deframer
  parameters: {}
  states: {}
- name: decode
  id: noaa_hrpt_decoder
  parameters:
    verbose: 'True'
    output: 'False'
  states: {}
- name: image
  id: hrpt_image_sink
  parameters:
    name: '"HRPT Image (channel 2)"'
    channel: '2'
    image_width: '2048'
    words_per_line: '11090'
    video_start: '751'
    invert: 'False'
    max_lines: '200'
  states: {}

connections:
- [src, '0', deframe, '0']
- [deframe, '0', decode, '0']
- [deframe, '0', image, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
