options:
  parameters:
    author: GNU Radio World
    description: Detects a narrowband tone in complex Gaussian noise with gr-inspector. Signal Detector calculates one 1024-bin periodogram at a time; Inspector GUI Sink plots it, overlays the detected RF map, and forwards that map to Message Debug. Enable Manual selection in the plot to drag a band instead.
    generate_options: qt_gui
    id: gr_inspector_Signal_Detector
    title: gr-inspector Signal Detector
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    comment: Periodogram size and detector decimation
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Complex baseband sample rate
    value: '48000'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: detector
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.8'
    comment: Mark periodogram bins above the fixed -30 dB threshold
    fft_len: fft_len
    logfile: ''
    min_bw: '0'
    quant: '0.001'
    samp_rate: samp_rate
    sensitivity: '0.2'
    threshold: '-30'
    window: window.WIN_HAMMING
  states: {}
- name: inspector_gui
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: '0'
    comment: Plot the PSD and detected bands; Ctrl+drag zooms, right-click zooms out
    fft_len: fft_len
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: '0.03'
    comment: Low background noise makes the occupied band easy to see
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: rf_map
  id: blocks_message_debug
  parameters:
    comment: Print RF-map changes as center-frequency and bandwidth pairs
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    comment: Pace the synthetic stream for the live display
    limit: time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    comment: Signal to locate at +8 kHz
    freq: '8000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [add, '0', throttle, '0']
- [detector, '0', inspector_gui, '0']
- {src_blk_id: detector, src_port_id: map_out, snk_blk_id: inspector_gui, snk_port_id: map_in}
- {src_blk_id: inspector_gui, src_port_id: map_out, snk_blk_id: rf_map, snk_port_id: print}
- [noise, '0', add, '1']
- [throttle, '0', detector, '0']
- [tone, '0', add, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
