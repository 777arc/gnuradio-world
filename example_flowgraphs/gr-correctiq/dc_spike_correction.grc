options:
  parameters:
    author: Marc
    description: A synthetic direct-conversion receiver signal with a controllable DC offset. The blue trace is the raw spectrum, whose offset appears as a spike at 0 Hz; the red trace passes through gr-correctiq's continuously adapting estimator, which removes the spike without offset tuning. Change DC offset amplitude while the graph runs to watch the correction follow it.
    generate_options: qt_gui
    id: gr_correctiq_DC_Spike_Correction
    title: gr-correctiq DC Spike Correction
  states: {}

blocks:
- name: dc_offset
  id: variable_qtgui_range
  parameters:
    comment: Simulates local-oscillator leakage in a direct-conversion receiver
    label: DC offset amplitude
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: corrected
  id: correctiq_correctiq
  parameters:
    comment: Continuously estimates and subtracts the mean I and Q values
  states: {}
- name: source
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: A 4 kHz signal plus complex DC offset
    freq: '4000'
    offset: dc_offset
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    bw: samp_rate
    comment: Blue is raw; red is corrected
    fc: '0'
    fftsize: '1024'
    label2: ''
    marker1: '-1'
    marker2: '-1'
    marker3: '-1'
    marker4: '-1'
    name: '"Raw vs corrected"'
    nconnections: '2'
    style1: '1'
    style2: '1'
    style3: '1'
    style4: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.05'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [corrected, '0', spectrum, '1']
- [source, '0', throttle, '0']
- [throttle, '0', corrected, '0']
- [throttle, '0', spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
