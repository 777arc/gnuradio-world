options:
  parameters:
    author: Marc
    description: Interactive real-time spectrum and waterfall display using gr-fosphor. A complex tone mixed with noise demonstrates fosphor's persistent color-density spectrum, live trace, and max hold. The browser uses WebGPU when available and automatically falls back to Qt 6 CPU plots; the editor console reports which renderer was selected.
    generate_options: qt_gui
    id: Fosphor_Spectrum_and_Waterfall
    title: Fosphor Spectrum and Waterfall
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: complex10
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: fosphor
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {}
- name: source9
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: cellular_downlink_880MHz
    repeat: 'False'
    type: short
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.05'
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [complex10, '0', throttle, '0']
- [source9, '0', complex10, '0']
- [throttle, '0', fosphor, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
