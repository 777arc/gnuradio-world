options:
  parameters:
    author: Marc
    description: A JavaScript Block reads and rewrites stream tags while a shipped message-only JavaScript block adds metadata to a PDU.
    generate_options: qt_gui
    id: JavaScript_Block___Tags_and_Messages
    title: JavaScript Block - Tags and Messages
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: input_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("input_tag")
    offset: '0'
    src: pmt.intern("tag_source")
    value: pmt.from_long(7)
  states: {}
- name: js_pdu
  id: js_pdu_length
  parameters: {}
  states: {}
- name: js_tags
  id: wasm_js_block
  parameters:
    _js_io: '{"decim":1,"doc":"","general":false,"hasStart":false,"hasStop":false,"history":1,"inputs":[{"dtype":"byte","vlen":1}],"interp":1,"label":"JS Tag Transform","numericParams":[],"outputMultiple":0,"outputs":[{"dtype":"byte","vlen":1}],"overridesForecast":false,"params":[],"relativeRate":1,"tagPropagation":3}'
    _js_source: ''
    _source_code: |
      gr.export({
        label: 'JS Tag Transform',
        inputs: ['byte'],
        outputs: ['byte'],

        init() {
          // TPP_CUSTOM means this block deliberately propagates its own tags.
          this.set_tag_propagation_policy(gr.TPP_CUSTOM);
        },

        work(nout, input, output) {
          output[0].set(input[0].subarray(0, nout));
          const read = this.nitems_read(0);
          const written = this.nitems_written(0);
          const key = pmt.intern('input_tag');

          // The range and window spellings return the same native four-field tags.
          const ranged = this.get_tags_in_range(0, read, read + nout, key);
          const windowed = this.get_tags_in_window(0, 0, nout, key);
          if (ranged.length !== windowed.length)
            throw new Error('tag range/window mismatch');

          for (const tag of windowed) {
            this.add_item_tag(
              0, written + tag.offset - read, pmt.intern('js_tag'),
              pmt.from_long(pmt.to_long(tag.value) + 1));
          }
          return nout;
        },
      });
  states: {}
- name: message_debug
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: message_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(4, [11, 22, 33, 44]))
    period: '500'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    name: Scope
    samp_rate: '200'
    size: '32'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '5'
    ymin: '0'
    yunit: ''
  states: {}
- name: tag_debug
  id: blocks_tag_debug
  parameters:
    filter: '"js_tag"'
    name: js_tag_output
    type: byte
  states: {}
- name: tag_source
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[input_tag]'
    type: byte
    vector: '[1, 2, 3, 4]'
  states: {}
- name: tag_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '200'
    type: byte
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- {src_blk_id: js_pdu, src_port_id: out, snk_blk_id: message_debug, snk_port_id: print_pdu}
- [js_tags, '0', blocks_char_to_float_0, '0']
- [js_tags, '0', tag_debug, '0']
- {src_blk_id: message_strobe, src_port_id: strobe, snk_blk_id: js_pdu, snk_port_id: in}
- [tag_source, '0', tag_throttle, '0']
- [tag_throttle, '0', js_tags, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
