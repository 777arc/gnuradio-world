options:
  parameters:
    author: Claude
    description: Arbitrary DSP in JavaScript -- a power-amplifier model written as a JS Block, its distortion driven live by sliders, followed by the repository's Complex Soft Clipper
    generate_options: qt_gui
    id: JavaScript_Block___Amplifier_Model
    title: JavaScript Block - Amplifier Model
  states: {}

blocks:
- name: am_pm
  id: variable_qtgui_range
  parameters:
    label: AM/PM conversion
    min_len: '240'
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0'
  states: {}
- name: clip_threshold
  id: variable_qtgui_range
  parameters:
    label: Clipper threshold
    min_len: '240'
    start: '0.1'
    step: '0.05'
    stop: '2'
    value: '2'
  states: {}
- name: drive
  id: variable_qtgui_range
  parameters:
    label: Amplifier drive
    min_len: '240'
    start: '0.1'
    step: '0.1'
    stop: '8'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: amplifier
  id: wasm_js_block
  parameters:
    _js_io: '{"decim":1,"doc":"AM/AM compression and AM/PM conversion, the way a real PA distorts.","general":false,"hasStart":false,"hasStop":false,"history":1,"inputs":[{"dtype":"complex","vlen":1}],"interp":1,"label":"Amplifier Model","numericParams":["drive","am_pm"],"outputMultiple":0,"outputs":[{"dtype":"complex","vlen":1}],"overridesForecast":false,"params":[["drive",1],["am_pm",0]],"relativeRate":1}'
    _js_source: ''
    _source_code: |
      // An amplifier, modelled in JavaScript.
      //
      // A real power amplifier does two things to a complex signal as it is driven
      // harder: it compresses the magnitude (AM/AM) and it shifts the phase in
      // proportion to the input power (AM/PM). Neither is a stock GNU Radio block, and
      // the two together are what turn a clean tone into the spectral regrowth you can
      // see on the Frequency Sink downstream.
      //
      // Both parameters are driven live by the sliders in this flowgraph: every numeric
      // parameter of a JS block gets a setter, so a QT GUI Range drives one exactly as
      // it drives a C++ block's.
      //
      // Double-click this block to open the code editor. The block's ports, parameters
      // and label all follow whatever you write, as you write it.
      gr.export({
        label: 'Amplifier Model',
        doc: 'AM/AM compression and AM/PM conversion, the way a real PA distorts.',
        inputs: ['complex'],
        outputs: ['complex'],
        params: { drive: 1.0, am_pm: 0.0 },

        work(nout, input, output) {
          const x = input[0], y = output[0];
          const drive = this.drive, amPm = this.am_pm;
          for (let i = 0; i < nout * 2; i += 2) {
            const re = x[i] * drive, im = x[i + 1] * drive;
            const power = re * re + im * im;
            // Rapp-style soft compression: unity gain at low drive, rolling off to a
            // magnitude of 1 as the input is pushed past it.
            const gain = 1 / Math.sqrt(1 + power * power);
            // AM/PM: the phase shift grows with the instantaneous power, which is what
            // makes the distortion asymmetric about the carrier.
            const shift = amPm * power;
            const c = Math.cos(shift), s = Math.sin(shift);
            y[i] = gain * (re * c - im * s);
            y[i + 1] = gain * (re * s + im * c);
          }
          return nout;
        },
      });
    am_pm: am_pm
    drive: drive
  states: {}
- name: clipper
  id: js_clip_cc
  parameters:
    knee: '0.5'
    threshold: clip_threshold
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: Amplifier output
    name: AM/AM and AM/PM
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: Amplifier output
    marker1: '-1'
    marker2: '-1'
    name: Spectral regrowth
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymin: '-90'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tone_a
  id: analog_sig_source_x
  parameters:
    amplitude: '0.5'
    frequency: '9000'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tone_b
  id: analog_sig_source_x
  parameters:
    amplitude: '0.5'
    frequency: '11000'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: two_tone
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [amplifier, '0', clipper, '0']
- [clipper, '0', constellation, '0']
- [clipper, '0', spectrum, '0']
- [throttle, '0', amplifier, '0']
- [tone_a, '0', two_tone, '0']
- [tone_b, '0', two_tone, '1']
- [two_tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
