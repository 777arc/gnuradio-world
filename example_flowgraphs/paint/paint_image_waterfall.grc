options:
  parameters:
    author: gr-paint (Ron Economos, W6RZ)
    description: Paint an image fetched from a URL into a waterfall display.
    generate_options: qt_gui
    id: paint_image_waterfall
    title: Paint an Image Into a Waterfall
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '163840'
  states: {}
- name: image
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: /example_images/gnuradio_logo.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: painter
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '4'
    width: '288'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '4096'
    int_max: '-57'
    int_min: '-83'
    name: Painted Spectrum
    samp_rate: samp_rate
    update_time: '0.025'
  states: {}

connections:
- [image, '0', painter, '0']
- [painter, '0', throttle, '0']
- [throttle, '0', waterfall, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
