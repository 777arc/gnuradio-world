options:
  parameters:
    author: Marc
    description: Note the BB60C is in IQ streaming mode
    generate_options: qt_gui
    id: Signal_Hound_BB60C_Spectrum_Analyzer
    title: Signal Hound BB60C Spectrum Analyzer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '95600000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    name: Scope
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    yunit: ''
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    average: '1.0'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: wasm_bb60_source_0
  id: wasm_bb60_source
  parameters:
    bandwidth: '0'
    center_freq: center_freq
    device: ''
    ref_level: '-70'
    samp_rate: samp_rate
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [wasm_bb60_source_0, '0', qtgui_freq_sink_x_0, '0']
- [wasm_bb60_source_0, '0', qtgui_time_sink_x_0, '0']
- [wasm_bb60_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
