options:
  parameters:
    author: GNU Radio World
    description: Three distinct signals across a simulated 1 MHz RF channel demonstrate automatic detection, per-signal peak measurement, center frequency, and 99% occupied bandwidth.
    generate_options: qt_gui
    id: Browser_Native_Spectrum_Analyzer
    title: Browser-Native Spectrum Analyzer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: ofdm_offset
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tone_offset
  id: variable
  parameters:
    value: '-300000'
  states: {}
- name: analyzer
  id: wasm_spectrum_analyzer_sink
  parameters:
    average: '0.2'
    center_freq: center_freq
    db_per_div: '10'
    fftsize: '8192'
    level_offset_db: '0'
    level_unit: dBFS
    name: Three-Signal Spectrum
    obw_percent: '99'
    obw_span: '0'
    peak_track: 'False'
    reference_level: '0'
    samp_rate: samp_rate
    trace_mode: average
    type: complex
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: channel_sum
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: channel_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"analyzer":[0,0,12,8]}'
    row_height: '60'
  states: {}
- name: ofdm_frequency_shift
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*ofdm_offset/samp_rate
  states: {}
- name: ofdm_level
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    mode: scalar
    type: complex
  states: {}
- name: ofdm_packet_tagger
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length
    packet_len: '96'
    type: byte
  states: {}
- name: ofdm_payload
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95]'
  states: {}
- name: ofdm_transmitter
  id: digital_ofdm_tx
  parameters:
    cp_len: '64'
    fft_len: '256'
    header_mod: '"BPSK"'
    packet_len_key: length
    payload_mod: '"QPSK"'
    rolloff: '0'
    scramble_bits: 'True'
  states: {}
- name: overview
  id: note
  parameters:
    note: |-
      A simulated 1 MHz channel centered at 915 MHz

      Left: narrow carrier at -300 kHz
      Center: pulse-shaped QPSK, 8 samples/symbol
      Right: QPSK OFDM at +300 kHz, 256-point FFT with 52 active carriers

      Low-level receiver noise gives the automatic detector a realistic floor to learn. Try changing Threshold, toggling Detect, or pressing Relearn in the running analyzer.
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: qpsk
  states: {}
- name: qpsk_data
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '23'
    type: byte
  states: {}
- name: qpsk_level
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.22'
    mode: scalar
    type: complex
  states: {}
- name: qpsk_modulator
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '8'
  states: {}
- name: receiver_noise
  id: analog_noise_source_x
  parameters:
    amp: '0.002'
    noise_type: analog.GR_GAUSSIAN
    seed: '7'
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: tone_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [channel_sum, '0', channel_throttle, '0']
- [channel_throttle, '0', analyzer, '0']
- [ofdm_frequency_shift, '0', channel_sum, '2']
- [ofdm_level, '0', ofdm_frequency_shift, '0']
- [ofdm_packet_tagger, '0', ofdm_transmitter, '0']
- [ofdm_payload, '0', ofdm_packet_tagger, '0']
- [ofdm_transmitter, '0', ofdm_level, '0']
- [qpsk_data, '0', qpsk_modulator, '0']
- [qpsk_level, '0', channel_sum, '1']
- [qpsk_modulator, '0', qpsk_level, '0']
- [receiver_noise, '0', channel_sum, '3']
- [tone, '0', channel_sum, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
