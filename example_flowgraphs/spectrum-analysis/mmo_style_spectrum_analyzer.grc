options:
  parameters:
    author: GNU Radio World
    description: Three independently fading signals across a simulated 1 MHz RF channel demonstrate the Spectrum Analyzer's MMO Mode with received-power health bars, leveling, damage effects, enemy classes, and a strongest-signal boss.
    generate_options: qt_gui
    id: MMO_Style_Spectrum_Analyzer
    title: MMO-Style Spectrum Analyzer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: ofdm_offset
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tone_offset
  id: variable
  parameters:
    value: '-300000'
  states: {}
- name: analyzer
  id: wasm_spectrum_analyzer_sink
  parameters:
    average: '0.2'
    center_freq: center_freq
    db_per_div: '10'
    fftsize: '8192'
    level_offset_db: '0'
    level_unit: dBFS
    mmo_mode: 'True'
    name: Three-Signal Spectrum
    reference_level: '0'
    samp_rate: samp_rate
    trace_mode: average
    type: complex
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: channel_sum
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: channel_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.02'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gui_layout
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"analyzer":[0,0,12,8]}'
    row_height: '60'
  states: {}
- name: ofdm_frequency_shift
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*ofdm_offset/samp_rate
  states: {}
- name: ofdm_level
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    mode: scalar
    type: complex
  states: {}
- name: ofdm_packet_tagger
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length
    packet_len: '96'
    type: byte
  states: {}
- name: ofdm_payload
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95]'
  states: {}
- name: ofdm_transmitter
  id: digital_ofdm_tx
  parameters:
    cp_len: '64'
    fft_len: '256'
    header_mod: '"BPSK"'
    packet_len_key: length
    payload_mod: '"QPSK"'
    rolloff: '0'
    scramble_bits: 'True'
  states: {}
- name: overview
  id: note
  parameters:
    note: |-
      A simulated 1 MHz channel centered at 915 MHz

      Left: narrow carrier at -300 kHz
      Center: pulse-shaped QPSK, 8 samples/symbol
      Right: QPSK OFDM at +300 kHz, 256-point FFT with 52 active carriers

      Each signal slowly eases toward an independent random power level every 3-7 seconds, making health changes and damage effects easy to see. Low-level receiver noise gives the automatic detector a realistic floor to learn.
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: qpsk
  states: {}
- name: qpsk_data
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '23'
    type: byte
  states: {}
- name: qpsk_level
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.22'
    mode: scalar
    type: complex
  states: {}
- name: qpsk_modulator
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '8'
  states: {}
- name: random_power_fades
  id: wasm_js_block
  parameters:
    _js_io: '{"decim":1,"doc":"Slow, independent random power changes for the three signals in the MMO spectrum demo.","general":false,"hasStart":true,"hasStop":false,"history":1,"inputs":[{"dtype":"complex","vlen":1},{"dtype":"complex","vlen":1},{"dtype":"complex","vlen":1}],"interp":1,"label":"Random Power Fades","numericParams":["sample_rate","min_gain","max_gain"],"outputMultiple":0,"outputs":[{"dtype":"complex","vlen":1},{"dtype":"complex","vlen":1},{"dtype":"complex","vlen":1}],"overridesForecast":false,"params":[["sample_rate",1000000],["min_gain",0.25],["max_gain",1.3]],"relativeRate":1}'
    _js_source: ''
    _source_code: |
      // Give each signal its own smooth, deterministic pseudo-random power envelope.
      gr.export({
        label: 'Random Power Fades',
        doc: 'Slow, independent random power changes for the three signals in the MMO spectrum demo.',
        inputs: ['complex', 'complex', 'complex'],
        outputs: ['complex', 'complex', 'complex'],
        params: { sample_rate: 1000000, min_gain: 0.25, max_gain: 1.3 },

        start() {
          this.rng = [0x13579bdf, 0x2468ace1, 0x10203040];
          this.gain = [1, 0.85, 1.15];
          this.step = [0, 0, 0];
          this.remaining = [0, 0, 0];
        },

        nextRandom(port) {
          this.rng[port] = (Math.imul(this.rng[port], 1664525) + 1013904223) >>> 0;
          return this.rng[port] / 4294967296;
        },

        chooseTarget(port) {
          const low = Math.min(this.min_gain, this.max_gain);
          const high = Math.max(this.min_gain, this.max_gain);
          const target = low + (high - low) * this.nextRandom(port);
          const seconds = 3 + 4 * this.nextRandom(port);
          const samples = Math.max(1, Math.round(seconds * Math.max(1, this.sample_rate)));
          this.step[port] = (target - this.gain[port]) / samples;
          this.remaining[port] = samples;
        },

        work(nout, input, output) {
          for (let port = 0; port < 3; port++) {
            const source = input[port];
            const destination = output[port];
            let gain = this.gain[port];
            let step = this.step[port];
            let remaining = this.remaining[port];

            for (let item = 0; item < nout; item++) {
              if (remaining <= 0) {
                this.gain[port] = gain;
                this.chooseTarget(port);
                step = this.step[port];
                remaining = this.remaining[port];
              }
              const offset = item * 2;
              destination[offset] = source[offset] * gain;
              destination[offset + 1] = source[offset + 1] * gain;
              gain += step;
              remaining--;
            }

            this.gain[port] = gain;
            this.step[port] = step;
            this.remaining[port] = remaining;
          }
          return nout;
        },
      });
    max_gain: '1.3'
    min_gain: '0.25'
    sample_rate: samp_rate
  states: {}
- name: receiver_noise
  id: analog_noise_source_x
  parameters:
    amp: '0.002'
    noise_type: analog.GR_GAUSSIAN
    seed: '7'
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: tone_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [channel_sum, '0', channel_throttle, '0']
- [channel_throttle, '0', analyzer, '0']
- [ofdm_frequency_shift, '0', random_power_fades, '2']
- [ofdm_level, '0', ofdm_frequency_shift, '0']
- [ofdm_packet_tagger, '0', ofdm_transmitter, '0']
- [ofdm_payload, '0', ofdm_packet_tagger, '0']
- [ofdm_transmitter, '0', ofdm_level, '0']
- [qpsk_data, '0', qpsk_modulator, '0']
- [qpsk_level, '0', random_power_fades, '1']
- [qpsk_modulator, '0', qpsk_level, '0']
- [random_power_fades, '0', channel_sum, '0']
- [random_power_fades, '1', channel_sum, '1']
- [random_power_fades, '2', channel_sum, '2']
- [receiver_noise, '0', channel_sum, '3']
- [tone, '0', random_power_fades, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
