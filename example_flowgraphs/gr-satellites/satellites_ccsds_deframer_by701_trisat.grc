options:
  parameters:
    author: Daniel Estevez
    description: 'CCSDS concatenated deframer on two recordings: BY70-1 as upstream has it, and TRISAT, which decodes here'
    generate_options: qt_gui
    id: gr_satellites_CCSDS_deframer__BY70_1__TRISAT_
    title: gr-satellites CCSDS deframer (BY70-1, TRISAT)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bpsk_demod
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}
- name: by701_deframer
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '114'
    precoding: '"differential"'
    rs_basis: '"conventional"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: by701_frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: by701_note
  id: note
  parameters:
    note: 'Upstream example: BY70-1, 9k6 BPSK, differential precoding, 114-byte frames. It decodes nothing in this runtime, though every block in it is proven working elsewhere.'
  states: {}
- name: by701_recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/by701
    repeat: 'False'
    type: short
  states: {}
- name: by701_recording_to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: fsk_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9766'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: trisat_deframer
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"NASA-DSN"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: trisat_frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: trisat_note
  id: note
  parameters:
    note: 'Same deframer block, TRISAT: 9766 baud FSK, NASA-DSN convolutional, dual-basis Reed-Solomon, 223-byte frames.'
  states: {}
- name: trisat_recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/trisat
    repeat: 'False'
    type: short
  states: {}
- name: trisat_recording_to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- [bpsk_demod, '0', by701_deframer, '0']
- {src_blk_id: by701_deframer, src_port_id: out, snk_blk_id: by701_frames, snk_port_id: print_pdu}
- [by701_recording, '0', by701_recording_to_float, '0']
- [by701_recording_to_float, '0', bpsk_demod, '0']
- [fsk_demod, '0', trisat_deframer, '0']
- {src_blk_id: trisat_deframer, src_port_id: out, snk_blk_id: trisat_frames, snk_port_id: print_pdu}
- [trisat_recording, '0', trisat_recording_to_float, '0']
- [trisat_recording_to_float, '0', fsk_demod, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
