options:
  parameters:
    author: Daniel Estevez
    description: AFSK demodulator component fed by the GOMX-1 recording
    generate_options: qt_gui
    id: afsk_demodulator_gomx1
    title: gr-satellites AFSK demodulator (GOMX-1)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: recording
  id: blocks_file_source
  parameters:
    file: /recordings/estevez/gomx_1.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: afsk_demod
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    samp_rate: samp_rate
  states: {}
- name: head
  id: blocks_head
  parameters:
    num_items: '8000'
    type: float
  states: {}
- name: soft_symbols
  id: qtgui_time_sink_x
  parameters:
    name: AFSK soft symbols
    samp_rate: '4800'
    size: '6000'
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
    yunit: ''
  states: {}

connections:
- [recording, '0', to_float, '0']
- [to_float, '0', afsk_demod, '0']
- [afsk_demod, '0', head, '0']
- [head, '0', soft_symbols, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
