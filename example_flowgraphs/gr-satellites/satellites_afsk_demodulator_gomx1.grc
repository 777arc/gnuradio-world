options:
  parameters:
    author: Daniel Estevez
    description: AFSK demodulator component fed by the GOMX-1 recording
    generate_options: qt_gui
    id: gr_satellites_AFSK_demodulator__GOMX_1_
    title: gr-satellites AFSK demodulator (GOMX-1)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: afsk_demod
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    samp_rate: samp_rate
  states: {}
- name: head
  id: blocks_head
  parameters:
    num_items: '8000'
    type: float
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/gomx_1
    repeat: 'False'
    type: short
  states: {}
- name: soft_symbols
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    name: AFSK soft symbols
    srate: '4800'
    size: '6000'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
    yunit: ''
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- [afsk_demod, '0', head, '0']
- [head, '0', soft_symbols, '0']
- [recording, '0', to_float, '0']
- [to_float, '0', afsk_demod, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
