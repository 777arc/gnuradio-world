options:
  parameters:
    author: Daniel Estevez
    description: 'LilacSat-1 image downlink: BPSK demodulator and LilacSat-1 deframer, printing the frames the image is carried in'
    generate_options: qt_gui
    id: gr_satellites_LilacSat_1_image_downlink
    title: gr-satellites LilacSat-1 image downlink
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bpsk_demod
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}
- name: deframer
  id: satellites_lilacsat_1_deframer
  parameters:
    threshold: '4'
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: image_note
  id: note
  parameters:
    note: Upstream assembles the JPEG with the Python image receiver, behind the all-in-one Satellite Decoder. Both are Python-only, so the chain is explicit here and the KISS frames carrying the image are printed.
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/lilacsat1-image
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- [bpsk_demod, '0', deframer, '0']
- {src_blk_id: deframer, src_port_id: out, snk_blk_id: frames, snk_port_id: print_pdu}
- [recording, '0', to_float, '0']
- [to_float, '0', bpsk_demod, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
