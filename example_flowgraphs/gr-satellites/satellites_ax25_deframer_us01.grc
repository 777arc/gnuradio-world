options:
  parameters:
    author: Daniel Estevez
    description: AX.25 deframer component fed by the US01 recording
    generate_options: no_gui
    id: ax25_deframer_us01
    title: gr-satellites AX.25 deframer (US01)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: recording
  id: blocks_file_source
  parameters:
    file: /recordings/estevez/us01.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: fsk_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9600'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: deframer
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [recording, '0', to_float, '0']
- [to_float, '0', fsk_demod, '0']
- [fsk_demod, '0', deframer, '0']
- {src_blk_id: deframer, src_port_id: out, snk_blk_id: frames, snk_port_id: print_pdu}

metadata:
  file_format: 2
  grc_version: 3.11.0.0
