options:
  parameters:
    author: Daniel Estevez
    description: 'GOMspace AX100 deframer in both its modes: ASM+Golay on the 1KUNS-PF recording, Reed-Solomon on the TW-1B recording'
    generate_options: qt_gui
    id: gr_satellites_AX100_deframer__1KUNS_PF__TW_1B_
    title: gr-satellites AX100 deframer (1KUNS-PF, TW-1B)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: asm_deframer
  id: satellites_ax100_deframer
  parameters:
    mode: '"ASM"'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: asm_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '1200'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: asm_frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: asm_note
  id: note
  parameters:
    note: ASM+Golay mode
  states: {}
- name: asm_recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/1kuns_pf
    repeat: 'False'
    type: short
  states: {}
- name: asm_recording_to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: rs_deframer
  id: satellites_ax100_deframer
  parameters:
    mode: '"RS"'
    threshold: '4'
  states: {}
- name: rs_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: rs_frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: rs_note
  id: note
  parameters:
    note: Reed-Solomon mode
  states: {}
- name: rs_recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/tw_1b
    repeat: 'False'
    type: short
  states: {}
- name: rs_recording_to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- {src_blk_id: asm_deframer, src_port_id: out, snk_blk_id: asm_frames, snk_port_id: print_pdu}
- [asm_demod, '0', asm_deframer, '0']
- [asm_recording, '0', asm_recording_to_float, '0']
- [asm_recording_to_float, '0', asm_demod, '0']
- {src_blk_id: rs_deframer, src_port_id: out, snk_blk_id: rs_frames, snk_port_id: print_pdu}
- [rs_demod, '0', rs_deframer, '0']
- [rs_recording, '0', rs_recording_to_float, '0']
- [rs_recording_to_float, '0', rs_demod, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
