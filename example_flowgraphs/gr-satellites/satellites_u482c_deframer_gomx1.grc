options:
  parameters:
    author: Daniel Estevez
    description: GOMspace U482C deframer fed by the GOMX-1 recording
    generate_options: qt_gui
    id: gr_satellites_U482C_deframer__GOMX_1_
    title: gr-satellites U482C deframer (GOMX-1)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: afsk_demod
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    samp_rate: samp_rate
  states: {}
- name: deframer
  id: satellites_u482c_deframer
  parameters:
    threshold: '4'
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/gomx_1
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- [afsk_demod, '0', deframer, '0']
- {src_blk_id: deframer, src_port_id: out, snk_blk_id: frames, snk_port_id: print_pdu}
- [recording, '0', to_float, '0']
- [to_float, '0', afsk_demod, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
