options:
  parameters:
    author: Daniel Estevez
    description: What the all-in-one Satellite Decoder expands to for AAUSAT-4, assembled from primitives because the deframer is Python-only
    generate_options: qt_gui
    id: gr_satellites_AAUSAT_4_decoder__assembled_
    title: gr-satellites AAUSAT-4 decoder (assembled)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decoder_note
  id: note
  parameters:
    note: 'Satellite Decoder and the AAUSAT-4 deframer are both Python-only, so the deframer is built here from the blocks it uses: soft syncword search, FSM removal, terminated r=1/2 K=7 Viterbi, CCSDS descrambling and Reed-Solomon. Only the long-frame branch is wired: the short one needs PDU To Tagged Stream, which this runtime does not schedule.'
  states: {}
- name: descrambler
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: fsk_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '2400'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: fsm
  id: satellites_aausat4_check_fsm
  parameters: {}
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/aausat_4
    repeat: 'False'
    type: short
  states: {}
- name: reed_solomon
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {}
- name: syncword
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2004'
    sync: '"010011110101101000110100010000110101010101000010"'
    threshold: '8'
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: viterbi
  id: fec_async_decoder
  parameters:
    decoder: viterbi_def
    mtu: '249'
    rev_pack: 'False'
  states: {}
- name: viterbi_def
  id: variable_cc_decoder_def
  parameters:
    framebits: '1996'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
    value: '"aausat4_long"'
  states: {}

connections:
- {src_blk_id: descrambler, src_port_id: out, snk_blk_id: reed_solomon, snk_port_id: in}
- [fsk_demod, '0', syncword, '0']
- {src_blk_id: fsm, src_port_id: long, snk_blk_id: viterbi, snk_port_id: in}
- [recording, '0', to_float, '0']
- {src_blk_id: reed_solomon, src_port_id: out, snk_blk_id: frames, snk_port_id: print_pdu}
- {src_blk_id: syncword, src_port_id: out, snk_blk_id: fsm, snk_port_id: in}
- [to_float, '0', fsk_demod, '0']
- {src_blk_id: viterbi, src_port_id: out, snk_blk_id: descrambler, snk_port_id: in}

metadata:
  file_format: 2
  grc_version: 3.11.0.0
