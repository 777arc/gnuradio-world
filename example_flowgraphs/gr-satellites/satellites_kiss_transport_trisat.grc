options:
  parameters:
    author: Daniel Estevez
    description: Deframed satellite frames timestamped for transport, in place of the Python KISS TCP transport
    generate_options: no_gui
    id: kiss_transport_trisat
    title: gr-satellites frame transport (TRISAT)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: recording
  id: blocks_file_source
  parameters:
    file: /recordings/estevez/trisat.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: fsk_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9766'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: deframer
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"NASA-DSN"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: timestamp
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: transport_note
  id: note
  parameters:
    note: 'Upstream sends these frames to a KISS TCP client through satellites_kiss_transport, a Python block: no C++ path, and no TCP sockets in the browser. Print timestamp + Message Debug is the log a KISS client would have printed. Upstream reads BY70-1 here, which does not decode in this runtime, so this uses TRISAT.'
  states: {}

connections:
- [recording, '0', to_float, '0']
- [to_float, '0', fsk_demod, '0']
- [fsk_demod, '0', deframer, '0']
- {src_blk_id: deframer, src_port_id: out, snk_blk_id: timestamp, snk_port_id: in}
- {src_blk_id: timestamp, src_port_id: out, snk_blk_id: frames, snk_port_id: print_pdu}

metadata:
  file_format: 2
  grc_version: 3.11.0.0
