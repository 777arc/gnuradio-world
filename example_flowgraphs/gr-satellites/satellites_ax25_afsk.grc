options:
  parameters:
    author: Daniel Estevez
    description: AX.25 over AFSK, transmitted and received in one flowgraph
    generate_options: qt_gui
    id: AX_25_AFSK_loopback_using_gr_satellites
    title: AX.25 AFSK loopback using gr-satellites
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: samp_rate/samp_per_sym
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: af_carrier
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1200'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analytic
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: audio_scope
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    marker1: '0'
    name: Transmitted AFSK audio
    samp_rate: samp_rate
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: bits_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: downmix
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fm_modulator
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*1000/samp_rate
  states: {}
- name: frame_tagger
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '32'
    type: byte
  states: {}
- name: framed_bits
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '4096'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: frames
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: hdlc_deframer
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: hdlc_framer
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: lo
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '-1700'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: matched_filter
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/samp_per_sym] * samp_per_sym'
    type: fff
  states: {}
- name: nrzi_decode
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: nrzi_encode
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: payload
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[130, 160, 144, 100, 96, 100, 96, 154, 96, 168, 144, 152, 64, 97, 3, 240, 72, 101, 108, 108, 111, 32, 102, 114, 111, 109, 32, 65, 88, 46, 50, 53]'
  states: {}
- name: payload_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*500)
  states: {}
- name: repeat
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: byte
  states: {}
- name: slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: symbol_scope
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    marker1: '0'
    name: Recovered soft symbols
    samp_rate: baudrate
    size: '256'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
    yunit: ''
  states: {}
- name: symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: '0.03'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: to_audio
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: to_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: upmix
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}

connections:
- [af_carrier, '0', upmix, '1']
- [analytic, '0', downmix, '1']
- [bits_to_float, '0', fm_modulator, '0']
- [downmix, '0', quad_demod, '0']
- [fm_modulator, '0', upmix, '0']
- [frame_tagger, '0', to_pdu, '0']
- [framed_bits, '0', nrzi_encode, '0']
- {src_blk_id: hdlc_deframer, src_port_id: out, snk_blk_id: frames, snk_port_id: print_pdu}
- {src_blk_id: hdlc_framer, src_port_id: out, snk_blk_id: framed_bits, snk_port_id: pdus}
- [lo, '0', downmix, '0']
- [matched_filter, '0', symbol_sync, '0']
- [nrzi_decode, '0', hdlc_deframer, '0']
- [nrzi_encode, '0', repeat, '0']
- [payload, '0', payload_throttle, '0']
- [payload_throttle, '0', frame_tagger, '0']
- [quad_demod, '0', matched_filter, '0']
- [repeat, '0', bits_to_float, '0']
- [slicer, '0', nrzi_decode, '0']
- [symbol_sync, '0', slicer, '0']
- [symbol_sync, '0', symbol_scope, '0']
- [to_audio, '0', analytic, '0']
- [to_audio, '0', audio_scope, '0']
- {src_blk_id: to_pdu, src_port_id: pdus, snk_blk_id: hdlc_framer, snk_port_id: in}
- [upmix, '0', to_audio, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
