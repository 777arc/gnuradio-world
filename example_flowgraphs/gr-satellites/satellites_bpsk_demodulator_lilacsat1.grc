options:
  parameters:
    author: Daniel Estevez
    description: BPSK demodulator component fed by the LilacSat-1 recording
    generate_options: qt_gui
    id: gr_satellites_BPSK_demodulator__LilacSat_1_
    title: gr-satellites BPSK demodulator (LilacSat-1)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bpsk_demod
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}
- name: head
  id: blocks_head
  parameters:
    num_items: '20000'
    type: float
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/lilacsat1
    repeat: 'False'
    type: short
  states: {}
- name: skiphead
  id: blocks_skiphead
  parameters:
    num_items: '10000'
    type: float
  states: {}
- name: soft_symbols
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    name: BPSK soft symbols
    srate: '9600'
    size: '20000'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
    yunit: ''
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- [bpsk_demod, '0', skiphead, '0']
- [head, '0', soft_symbols, '0']
- [recording, '0', to_float, '0']
- [skiphead, '0', head, '0']
- [to_float, '0', bpsk_demod, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
