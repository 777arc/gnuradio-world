options:
  parameters:
    author: Daniel Estevez
    description: BPSK demodulator component fed by the LilacSat-1 recording
    generate_options: qt_gui
    id: bpsk_demodulator_lilacsat1
    title: gr-satellites BPSK demodulator (LilacSat-1)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: recording
  id: blocks_file_source
  parameters:
    file: /recordings/estevez/lilacsat1.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: bpsk_demod
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}
- name: skiphead
  id: blocks_skiphead
  parameters:
    num_items: '10000'
    type: float
  states: {}
- name: head
  id: blocks_head
  parameters:
    num_items: '20000'
    type: float
  states: {}
- name: soft_symbols
  id: qtgui_time_sink_x
  parameters:
    name: BPSK soft symbols
    samp_rate: '9600'
    size: '20000'
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
    yunit: ''
  states: {}

connections:
- [recording, '0', to_float, '0']
- [to_float, '0', bpsk_demod, '0']
- [bpsk_demod, '0', skiphead, '0']
- [skiphead, '0', head, '0']
- [head, '0', soft_symbols, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
