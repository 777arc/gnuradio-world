options:
  parameters:
    author: Daniel Estevez
    description: FSK demodulator component fed by the AAUSAT-4 recording
    generate_options: qt_gui
    id: fsk_demodulator_aausat4
    title: gr-satellites FSK demodulator (AAUSAT-4)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: recording
  id: blocks_file_source
  parameters:
    file: /recordings/estevez/aausat_4.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: fsk_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: soft_symbols
  id: qtgui_time_sink_x
  parameters:
    name: FSK soft symbols
    samp_rate: '4800'
    size: '12000'
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
    yunit: ''
  states: {}

connections:
- [recording, '0', to_float, '0']
- [to_float, '0', fsk_demod, '0']
- [fsk_demod, '0', soft_symbols, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
