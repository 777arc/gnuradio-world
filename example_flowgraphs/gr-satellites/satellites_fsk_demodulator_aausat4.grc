options:
  parameters:
    author: Daniel Estevez
    description: FSK demodulator component fed by the AAUSAT-4 recording
    generate_options: qt_gui
    id: gr_satellites_FSK_demodulator__AAUSAT_4_
    title: gr-satellites FSK demodulator (AAUSAT-4)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fsk_demod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: recording
  id: wasm_gr_world_recording
  parameters:
    length: '0'
    offset: '0'
    progress: 'True'
    recording: estevez/aausat_4
    repeat: 'False'
    type: short
  states: {}
- name: soft_symbols
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    name: FSK soft symbols
    srate: '4800'
    size: '12000'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '4'
    ymin: '-4'
    yunit: ''
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}

connections:
- [fsk_demod, '0', soft_symbols, '0']
- [recording, '0', to_float, '0']
- [to_float, '0', fsk_demod, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
