options:
  parameters:
    author: Communications Engineering Lab, KIT
    description: 'An FSK radar measuring one simulated target: two alternating tones bounce off something 200 m away closing at 20 m/s, and the range and velocity that come back out are plotted live. Move the target with the two sliders and watch the measurement follow it. Adapted from gr-radar''s own examples/simulation/simulator_fsk.grc.'
    generate_options: qt_gui
    id: FSK_radar_simulator
    title: FSK radar simulator
  states: {}

blocks:
- name: R_max
  id: variable
  parameters:
    comment: Unambiguous range, metres
    value: 3e8/2/delta_freq
  states: {}
- name: blocks_per_tag
  id: variable
  parameters:
    comment: Tone pairs per measurement
    value: '16384'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Carrier the Doppler shift
      is measured against
    value: '2400000000'
  states: {}
- name: cfar_mult
  id: variable_qtgui_range
  parameters:
    comment: Raises the detector's threshold above the noise floor
    label: CFAR threshold multiplier
    start: '1'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: delta_freq
  id: variable
  parameters:
    comment: |-
      Tone spacing; range comes from
      the phase difference between the two
    value: samp_rate/4
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/2/blocks_per_tag
  states: {}
- name: min_output_buffer
  id: variable
  parameters:
    comment: |-
      Two packets, so every
      tagged-stream block has
      room for one
    value: 4*blocks_per_tag*samp_per_freq
  states: {}
- name: samp_per_freq
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: target_range
  id: variable_qtgui_range
  parameters:
    label: Target Range [m]
    start: '50'
    step: '1'
    stop: '500'
    value: '200'
  states: {}
- name: target_velocity
  id: variable_qtgui_range
  parameters:
    label: Target Velocity [m/s]
    start: '5'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: v_res
  id: variable
  parameters:
    comment: Velocity resolution, m/s
    value: freq_res*3e8/2/center_freq
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    comment: Echo plus receiver noise
    minoutbuf: min_output_buffer
    type: complex
  states: {}
- name: cfar
  id: radar_os_cfar_c
  parameters:
    comment: Constant-false-alarm-rate peak detector
    len_key: '"packet_len"'
    merge_consecutive: 'True'
    minoutbuf: min_output_buffer
    mult_threshold: cfar_mult
    rel_threshold: '0.78'
    samp_compare: '15'
    samp_protect: '0'
    samp_rate: samp_rate//2
  states: {}
- name: cross
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Phase difference between the two tones' spectra
    minoutbuf: min_output_buffer
  states: {}
- name: dechirp
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Mixes the echo down against the transmitted signal
    minoutbuf: min_output_buffer
  states: {}
- name: estimator
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    comment: Peak position gives velocity, peak phase gives range
    delta_freq: delta_freq
    push_power: 'False'
  states: {}
- name: fft_high
  id: radar_ts_fft_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    packet_len: blocks_per_tag*samp_per_freq
  states: {}
- name: fft_low
  id: radar_ts_fft_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    packet_len: blocks_per_tag*samp_per_freq
  states: {}
- name: fsk_gen
  id: radar_signal_generator_fsk_c
  parameters:
    amplitude: '1'
    blocks_per_tag: blocks_per_tag
    freq_high: delta_freq/2
    freq_low: '-delta_freq/2'
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    samp_per_freq: samp_per_freq
    samp_rate: samp_rate
  states: {}
- name: gate
  id: radar_msg_gate
  parameters:
    comment: |-
      Drops detections outside the
      plotted velocity range -- chiefly
      the residual of the tone step itself,
      which lands near -delta_freq
    msg_keys: ('velocity',)
    val_max: '[60]'
    val_min: '[-60]'
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amplitude: '0.5'
    minoutbuf: min_output_buffer
    seed: '0'
    type: complex
  states: {}
- name: range_plot
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0, 550]'
    interval: '100'
    label_y: '''range'''
    range_time: '10'
  states: {}
- name: results
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: scatter
  id: radar_qtgui_scatter_plot
  parameters:
    axis_x: '[0, 550]'
    axis_y: '[-10, 60]'
    interval: '250'
    label_x: '''range'''
    label_y: '''velocity'''
  states: {}
- name: split
  id: radar_split_fsk_cc
  parameters:
    comment: One stream per tone
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    samp_discard: '0'
    samp_per_freq: samp_per_freq
  states: {}
- name: target
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '[0]'
    center_freq: center_freq
    comment: Delays and Doppler-shifts the transmitted tones
    len_key: '"packet_len"'
    minoutbuf: min_output_buffer
    position_rx: '[0]'
    range: target_range
    rcs: '[1e16]'
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-10'
    velocity: target_velocity
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    minoutbuf: min_output_buffer
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: velocity_plot
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[-10, 60]'
    interval: '100'
    label_y: '''velocity'''
    range_time: '10'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"cfar_mult":[3,1,6,1],"range_plot":[0,2,6,6],"scatter":[0,8,12,6],"target_range":[0,0,6,1],"target_velocity":[6,0,6,1],"velocity_plot":[6,2,6,6]}'
    row_height: '60'
  states: {}

connections:
- [add, '0', dechirp, '0']
- {src_blk_id: cfar, src_port_id: Msg out, snk_blk_id: estimator, snk_port_id: Msg in}
- [cross, '0', cfar, '0']
- [dechirp, '0', split, '0']
- {src_blk_id: estimator, src_port_id: Msg out, snk_blk_id: gate, snk_port_id: Msg in}
- [fft_high, '0', cross, '0']
- [fft_low, '0', cross, '1']
- [fsk_gen, '0', throttle, '0']
- {src_blk_id: gate, src_port_id: Msg out, snk_blk_id: range_plot, snk_port_id: Msg in}
- {src_blk_id: gate, src_port_id: Msg out, snk_blk_id: results, snk_port_id: Msg in}
- {src_blk_id: gate, src_port_id: Msg out, snk_blk_id: scatter, snk_port_id: Msg in}
- {src_blk_id: gate, src_port_id: Msg out, snk_blk_id: velocity_plot, snk_port_id: Msg in}
- [noise, '0', add, '0']
- [split, '0', fft_low, '0']
- [split, '1', fft_high, '0']
- [target, '0', add, '1']
- [throttle, '0', dechirp, '1']
- [throttle, '0', target, '0']

metadata:
  file_format: 2
  grc_version: 3.11.0.0
