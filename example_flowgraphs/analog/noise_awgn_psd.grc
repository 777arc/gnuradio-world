options:
  parameters:
    author: Marc
    description: Companion to the Noise chapter of PySDR
    generate_options: qt_gui
    id: PySDR__AWGN_in_Time__Frequency__and_Distribution
    title: 'PySDR: AWGN in Time, Frequency, and Distribution'
  states: {}

blocks:
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: tone_amp
  id: variable_qtgui_range
  parameters:
    label: Signal amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.1'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: '"Power spectral density"'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    type: complex
    update_time: '0.1'
    ymin: '-120'
  states: {}
- name: hist_sink
  id: qtgui_histogram_sink_x
  parameters:
    alpha1: '1'
    bins: '200'
    grid: 'True'
    name: '"Distribution of the I samples"'
    size: '2048'
    type: float
    update_time: '0.1'
    xmax: '1'
    xmin: '-1'
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amplitude: noise_amp
    seed: '0'
    type: complex
  states: {}
- name: note_psd
  id: note
  parameters:
    note: |-
      Slide the two amplitudes against each other to change SNR

      PSD looks like grass until you turn on averaging in the sink control panel
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    grid: 'True'
    name: '"Noise in the time domain"'
    samp_rate: samp_rate
    size: '1024'
    tr_level: '0'
    type: complex
    update_time: '0.1'
  states: {}
- name: to_real
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amplitude: tone_amp
    frequency: '10000'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"freq_sink":[0,1,6,4],"hist_sink":[0,5,12,4],"noise_amp":[0,0,5,1],"time_sink":[6,1,6,4],"tone_amp":[7,0,5,1]}'
    row_height: '60'
  states: {}

connections:
- [add, '0', throttle, '0']
- [noise, '0', add, '0']
- [throttle, '0', freq_sink, '0']
- [throttle, '0', time_sink, '0']
- [throttle, '0', to_real, '0']
- [to_real, '0', hist_sink, '0']
- [tone, '0', add, '1']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
