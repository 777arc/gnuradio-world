options:
  parameters:
    author: Claude
    description: Noisy FM transmitter and quadrature-demodulator loopback with live tone and noise controls
    generate_options: qt_gui
    id: FM_Loopback
    title: FM Loopback
  states: {}

blocks:
- name: noise_amplitude
  id: variable_qtgui_range
  parameters:
    label: Channel noise
    min_len: '240'
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: tone_frequency
  id: variable_qtgui_range
  parameters:
    label: Message tone frequency
    min_len: '240'
    start: '200'
    step: '100'
    stop: '3000'
    value: '1000'
  states: {}
- name: channel_noise
  id: analog_noise_source_x
  parameters:
    amplitude: noise_amplitude
    seed: '7'
    type: complex
  states: {}
- name: fm_demodulator
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.5278874537'
  states: {}
- name: fm_modulator
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.6544984695'
  states: {}
- name: fm_spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: Noisy FM signal
    marker1: '-1'
    name: FM Channel Spectrum
    samp_rate: '48000'
    style1: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: message_tone
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: tone_frequency
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: noisy_channel
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: recovered_message
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    label1: Recovered tone
    name: Recovered FM Message
    samp_rate: '48000'
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: ''
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}

connections:
- [channel_noise, '0', noisy_channel, '1']
- [fm_demodulator, '0', recovered_message, '0']
- [fm_modulator, '0', noisy_channel, '0']
- [message_tone, '0', fm_modulator, '0']
- [noisy_channel, '0', throttle, '0']
- [throttle, '0', fm_demodulator, '0']
- [throttle, '0', fm_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
