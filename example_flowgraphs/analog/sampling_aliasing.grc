options:
  parameters:
    author: PySDR
    description: Companion to the Sampling chapter of PySDR
    generate_options: qt_gui
    id: PySDR__Nyquist_Sampling_and_Aliasing
    title: 'PySDR: Nyquist Sampling and Aliasing'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    label: Tone frequency (Hz)
    start: '100'
    step: '100'
    stop: '100000'
    value: '2000'
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: '"Where the tone appears"'
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    type: float
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: note_nyq
  id: note
  parameters:
    note: Fs = 100 kHz, so Nyquist is 50 kHz. Sweep the tone past 50 kHz and watch the peak fold back
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    marker1: '0'
    name: '"Samples in the time domain"'
    samp_rate: samp_rate
    size: '200'
    tr_level: '0'
    type: float
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: tone_freq
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [throttle, '0', freq_sink, '0']
- [throttle, '0', time_sink, '0']
- [tone, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
