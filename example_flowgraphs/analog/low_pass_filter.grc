options:
  parameters:
    author: Claude
    description: Compare a two-tone signal before and after a 5 kHz low-pass FIR filter
    generate_options: qt_gui
    id: Low_Pass_Filter
    title: Low-Pass Filter
  states: {}

blocks:
- name: low_pass
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: passband_tone
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '2000'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: spectrum_after
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    color1: '"green"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: Filtered
    marker1: '-1'
    name: After Filter - 12 kHz Rejected
    samp_rate: '48000'
    style1: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: spectrum_before
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: Unfiltered
    marker1: '-1'
    name: Before Filter - 2 kHz and 12 kHz
    samp_rate: '48000'
    style1: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: stopband_tone
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '12000'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: two_tones
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}

connections:
- [low_pass, '0', spectrum_after, '0']
- [passband_tone, '0', two_tones, '0']
- [stopband_tone, '0', two_tones, '1']
- [throttle, '0', low_pass, '0']
- [throttle, '0', spectrum_before, '0']
- [two_tones, '0', throttle, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
