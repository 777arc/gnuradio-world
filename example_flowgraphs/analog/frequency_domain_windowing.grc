options:
  parameters:
    author: PySDR
    description: Companion to the Frequency Domain chapter of PySDR
    generate_options: qt_gui
    id: PySDR__Windowing__FFT_Size__and_the_Waterfall
    title: 'PySDR: Windowing, FFT Size, and the Waterfall'
  states: {}

blocks:
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Noise amplitude
    start: '0'
    step: '0.001'
    stop: '0.05'
    value: '0.001'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: strong_freq
  id: variable_qtgui_range
  parameters:
    label: Strong tone (Hz)
    start: '-40000'
    step: '500'
    stop: '40000'
    value: '10000'
  states: {}
- name: weak_amp
  id: variable_qtgui_range
  parameters:
    label: Weak tone amplitude
    start: '0.0001'
    step: '0.0001'
    stop: '0.1'
    value: '0.003'
  states: {}
- name: weak_freq
  id: variable_qtgui_range
  parameters:
    label: Weak tone (Hz)
    start: '-40000'
    step: '500'
    stop: '40000'
    value: '12000'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.1'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amplitude: noise_amp
    seed: '0'
    type: complex
  states: {}
- name: note_two
  id: note
  parameters:
    note: |-
      Two tones, one of them much weaker. Slide them together and watch the point where the FFT stops resolving them as two

      The sidelobes of the strong tone's window are what buries the weak one. Raise the FFT Size on the Frequency Sink to narrow each bin and the two separate sooner
  states: {}
- name: strong_tone
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: strong_freq
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"freq_sink":[0,3,12,4],"noise_amp":[0,0,12,1],"strong_freq":[0,1,12,1],"waterfall_sink":[0,7,12,4],"weak_amp":[6,2,6,1],"weak_freq":[0,2,6,1]}'
    row_height: '60'
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    name: Waterfall
    samp_rate: samp_rate
    update_time: '0.1'
  states: {}
- name: weak_tone
  id: analog_sig_source_x
  parameters:
    amplitude: weak_amp
    frequency: weak_freq
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [add, '0', throttle, '0']
- [noise, '0', add, '2']
- [strong_tone, '0', add, '0']
- [throttle, '0', freq_sink, '0']
- [throttle, '0', waterfall_sink, '0']
- [weak_tone, '0', add, '1']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
