options:
  parameters:
    author: Claude
    description: Interactive amplitude modulation demo with time- and frequency-domain views
    generate_options: qt_gui
    id: AM_Modulation
    title: AM Modulation
  states: {}

blocks:
- name: modulation_depth
  id: variable_qtgui_range
  parameters:
    label: Modulation depth
    min_len: '240'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.7'
  states: {}
- name: am_spectrum
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label1: AM signal
    marker1: '-1'
    name: AM Spectrum - Carrier and Sidebands
    samp_rate: '48000'
    style1: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
    ymin: '-100'
  states: {}
- name: am_waveform
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    grid: 'True'
    label1: In-phase
    label2: Quadrature
    name: AM Waveform and Envelope
    samp_rate: '48000'
    size: '1024'
    tr_level: '0'
    tr_tag: ''
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
    yunit: ''
  states: {}
- name: audio_tone
  id: analog_sig_source_x
  parameters:
    amplitude: modulation_depth
    frequency: '1000'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: carrier
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '10000'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: carrier_level
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: envelope
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: envelope_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: modulator
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}

connections:
- [audio_tone, '0', envelope, '0']
- [carrier, '0', modulator, '1']
- [carrier_level, '0', envelope, '1']
- [envelope, '0', envelope_to_complex, '0']
- [envelope_to_complex, '0', modulator, '0']
- [modulator, '0', throttle, '0']
- [throttle, '0', am_spectrum, '0']
- [throttle, '0', am_waveform, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
