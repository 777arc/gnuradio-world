options:
  parameters:
    author: Marc
    generate_options: qt_gui
    id: RTL_SDR_Simple_Example
    title: RTL-SDR Simple Example
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: '71000000'
    step: '500000'
    stop: '2000000000'
    value: '100000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '49'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    average: '0.1'
    fc: center_freq
    fftsize: '2048'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    samp_rate: samp_rate
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    fc: center_freq
    fftsize: '1024'
    name: Waterfall
    samp_rate: samp_rate
    update_time: '0.1'
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{"center_freq":[0,0,7,1],"gain":[8,0,4,1],"qtgui_freq_sink_x_0":[0,1,12,3],"qtgui_waterfall_sink_x_0":[0,4,12,6]}'
    row_height: '60'
  states: {}
- name: wasm_rtlsdr_source_0
  id: wasm_rtlsdr_source
  parameters:
    bias_tee: 'False'
    bufflen: '262144'
    center_freq: center_freq
    device: ''
    direct_samp: '0'
    freq_correction: '0'
    gain: gain
    gain_mode: 'False'
    samp_rate: samp_rate
    type: complex
  states: {}

connections:
- [wasm_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [wasm_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
