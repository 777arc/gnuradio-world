options:
  parameters:
    id: wasm_musical_keyboard_source
    title: Musical Keyboard Source smoke test
  states: {}

blocks:
- name: keyboard
  id: wasm_musical_keyboard_source
  parameters:
    amplitude: '0.2'
    attack_ms: '5'
    default_chord: major_seventh
    first_note: '48'
    maxoutbuf: '16'
    octaves: '2'
    release_ms: '50'
    samp_rate: '48000'
    tuning_hz: '440'
    waveform: sine
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.01'
    samples_per_second: '48000'
    type: float
  states: {}
- name: sink
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [keyboard, '0', throttle, '0']
- [throttle, '0', sink, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
