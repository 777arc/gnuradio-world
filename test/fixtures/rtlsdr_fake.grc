options:
  parameters:
    id: rtlsdr_fake
  states: {}

blocks:
- name: rtl
  id: wasm_rtlsdr_source
  parameters:
    device: fake:100000
    type: complex
    samp_rate: '1024000'
    center_freq: '100000000'
    gain_mode: 'False'
    gain: '30'
    freq_correction: '0'
    direct_samp: '0'
    bias_tee: 'False'
    bufflen: '16384'
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}

connections:
- [rtl, '0', mag, '0']
- [mag, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
