options:
  parameters:
    id: wasm_js_repo_blocks
    generate_options: qt_gui
  states: {}

blocks:
- name: clip_source
  id: analog_sig_source_x
  parameters:
    amplitude: '2'
    frequency: '0'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: clip_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: complex
  states: {}
- name: clip
  id: js_clip_cc
  parameters:
    threshold: '0.5'
    knee: '0'
  states: {}
- name: clip_mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: probe_clip
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: peak_source
  id: analog_sig_source_x
  parameters:
    amplitude: '-3'
    frequency: '0'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: peak_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: float
  states: {}
- name: peak_hold
  id: js_peak_hold_ff
  parameters:
    absolute: '1'
  states: {}
- name: probe_peak
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: phase_source
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: phase_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: complex
  states: {}
- name: to_arg
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: unwrap
  id: js_phase_unwrap_ff
  parameters: {}
  states: {}
- name: unwrap_sink
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [clip_source, '0', clip_throttle, '0']
- [clip_throttle, '0', clip, '0']
- [clip, '0', clip_mag, '0']
- [clip_mag, '0', probe_clip, '0']
- [peak_source, '0', peak_throttle, '0']
- [peak_throttle, '0', peak_hold, '0']
- [peak_hold, '0', probe_peak, '0']
- [phase_source, '0', phase_throttle, '0']
- [phase_throttle, '0', to_arg, '0']
- [to_arg, '0', unwrap, '0']
- [unwrap, '0', unwrap_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
