options:
  parameters:
    id: file_source_offset
  states: {}

blocks:
- name: source
  id: blocks_file_source
  parameters:
    file: /recordings/fm_rds_250k_1Msamples.sigmf-data
    length: '1'
    offset: '3'
    repeat: 'False'
    type: complex
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}

connections:
- [source, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
