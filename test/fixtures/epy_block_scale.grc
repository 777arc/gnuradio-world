options:
  parameters:
    id: epy_block_scale
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # a Python comment, which the YAML reader must not mistake for its own
          """Halve the rate and scale"""

          def __init__(self, scale=1.0):
              gr.decim_block.__init__(self, name='Scaling Decimator',
                                      in_sig=[np.float32], out_sig=[np.float32], decim=2)
              self.scale = scale

          def work(self, input_items, output_items):
              n = len(output_items[0])
              output_items[0][:] = input_items[0][:2 * n:2] * self.scale
              if self.nitems_written(0) == 0:
                  print('epy first output %.3f' % output_items[0][0])
              return n
    scale: samp_rate / 32000 * 4
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_probe_signal_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
