options:
  parameters:
    id: hackrf_fake
  states: {}

blocks:
- name: hackrf_rx
  id: wasm_hackrf_source
  parameters:
    device: fake:100000
    samp_rate: '2000000'
    center_freq: '100000000'
    bandwidth: '0'
    lna_gain: '16'
    vga_gain: '16'
    amp: 'False'
    bias_tee: 'False'
    transfer_size: '32768'
  states: {}
- name: rx_null
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: '2000000'
    waveform: analog.GR_COS_WAVE
    freq: '100000'
    amp: '0.01'
    offset: '0'
    phase: '0'
  states: {}
- name: hackrf_tx
  id: wasm_hackrf_sink
  parameters:
    device: fake
    samp_rate: '2000000'
    center_freq: '100000000'
    bandwidth: '0'
    txvga_gain: '0'
    amp: 'False'
    bias_tee: 'False'
    transfer_size: '32768'
  states: {}

connections:
- [hackrf_rx, '0', rx_null, '0']
- [tone, '0', hackrf_tx, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
