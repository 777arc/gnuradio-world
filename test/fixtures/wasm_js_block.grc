options:
  parameters:
    id: wasm_js_block
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: float_source
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: float
  states: {}
- name: js_scale
  id: wasm_js_block
  parameters:
    _source_code: |
      // A decimating JS block: the fixture covers the parts a plain sync block would
      // not -- decimation, history, a live-settable parameter, and consume_each of
      // decim * produced.
      gr.export({
        label: 'JS Scaling Decimator',
        inputs: ['float'],
        outputs: ['float'],
        params: { scale: 1.0 },
        decimation: 2,
        start() { this.total = 0; },
        work(nout, input, output) {
          const x = input[0], y = output[0], s = this.scale;
          for (let i = 0; i < nout; i++) y[i] = x[i * 2] * s;
          if (this.total === 0) this.log('first output ' + y[0].toFixed(3));
          this.total += nout;
          return nout;
        },
      });
    scale: '4'
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: complex_source
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: complex_throttle
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: complex
  states: {}
- name: js_passthrough
  id: wasm_js_block
  parameters:
    _source_code: |
      // A general block: generalWork() plus a synchronous this.consume(port, n).
      // Complex in, complex out, 1:1, consuming exactly what it produced.
      gr.export({
        label: 'JS Passthrough',
        inputs: ['complex'],
        outputs: ['complex'],
        generalWork(nout, nin, input, output) {
          const n = Math.min(nout, nin[0]);
          const x = input[0], y = output[0];
          for (let i = 0; i < n * 2; i++) y[i] = x[i];
          this.consume(0, n);
          return n;
        },
      });
  states: {}
- name: complex_sink
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [float_source, '0', throttle, '0']
- [throttle, '0', js_scale, '0']
- [js_scale, '0', probe, '0']
- [complex_source, '0', complex_throttle, '0']
- [complex_throttle, '0', js_passthrough, '0']
- [js_passthrough, '0', complex_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
