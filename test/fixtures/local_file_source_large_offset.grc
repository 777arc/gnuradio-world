options:
  parameters:
    id: local_file_source_large_offset
  states: {}

blocks:
- name: source
  id: blocks_file_source
  parameters:
    file: select-in-browser.bin
    length: '1'
    offset: '4294967312'
    repeat: 'False'
    type: byte
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}

connections:
- [source, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
