options:
  parameters:
    id: local_image_source
  states: {}

blocks:
- name: image
  id: paint_image_source
  parameters:
    image_file: select-in-browser.svg
    image_flip: '0'
    bt709_map: '0'
    image_invert: '0'
    autocontrast: '0'
    repeatmode: '1'
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.02'
    samples_per_second: '32000'
    type: byte
  states: {}

connections:
- [image, '0', throttle, '0']
- [throttle, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
