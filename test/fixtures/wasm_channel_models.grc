options:
  parameters:
    id: wasm_channel_models
    title: WASM gr-channels models
  states: {}

blocks:
- name: source
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: '32000'
    waveform: analog.GR_COS_WAVE
    freq: '1000'
    amp: '1'
    offset: '0'
    phase: '0'
  states: {}
- name: cfo
  id: channels_cfo_model
  parameters:
    srate: '32000'
    stdev: '0.01'
    maxdev: '1000'
    seed: '0'
  states: {}
- name: sro
  id: channels_sro_model
  parameters:
    srate: '32000'
    stdev: '0.01'
    maxdev: '1000'
    seed: '0'
  states: {}
- name: model2
  id: channels_channel_model2
  parameters:
    noise_voltage: '0.01'
    epsilon: '1.0'
    taps: '[1.0]'
    seed: '0'
  states: {}
- name: selective2
  id: channels_selective_fading_model2
  parameters:
    N: '8'
    fDTs: '0.00000625'
    LOS: 'True'
    K: '4.0'
    seed: '0'
    delays: '[1.0, 1.9, 2.7]'
    delay_std: '[0.0001, 0.0001, 0.0001]'
    delay_maxdev: '[0.5, 0.7, 0.9]'
    mags: '[1, 0.95, 0.8]'
    ntaps: '8'
  states: {}
- name: dynamic
  id: channels_dynamic_channel_model
  parameters:
    samp_rate: '32000'
    cfo_stdev: '0.01'
    cfo_maxdev: '1000'
    sro_stdev: '0.01'
    sro_maxdev: '1000'
    noise_amp: '0.01'
    N: '8'
    fD: '2.0'
    LOS: 'True'
    K: '4.0'
    seed: '0'
    delays: '[0.0, 0.1, 1.3]'
    mags: '[1, 0.99, 0.97]'
    ntaps: '8'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: '32000'
  states: {}
- name: sink
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: freq_offset
  id: analog_const_source_x
  parameters:
    type: float
    const: '50'
  states: {}
- name: timing_offset
  id: analog_const_source_x
  parameters:
    type: float
    const: '1.0'
  states: {}

connections:
- [freq_offset, '0', model2, '1']
- [timing_offset, '0', model2, '2']
- [source, '0', cfo, '0']
- [cfo, '0', sro, '0']
- [sro, '0', model2, '0']
- [model2, '0', selective2, '0']
- [selective2, '0', dynamic, '0']
- [dynamic, '0', throttle, '0']
- [throttle, '0', sink, '0']

metadata:
  file_format: 1
