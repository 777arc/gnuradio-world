options:
  parameters:
    id: usrp_b2xx_fake
  states: {}

blocks:
- name: usrp_rx
  id: wasm_usrp_b2xx_source
  parameters:
    device: fake:100000
    samp_rate: '1000000'
    center_freq: '100000000'
    gain: '30'
    bandwidth: '0'
    antenna: RX2
    master_clock_rate: '0'
  states: {}
- name: rx_null
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [usrp_rx, '0', rx_null, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
