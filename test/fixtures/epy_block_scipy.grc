options:
  parameters:
    id: epy_block_scipy
    generate_options: qt_gui
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amplitude: '1'
    frequency: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: '32000'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from scipy.signal import fftconvolve
      from gnuradio import gr


      class blk(gr.sync_block):
          """Filter with scipy, whose wheel is fetched from this source's imports"""

          def __init__(self, gain=1.0):
              gr.sync_block.__init__(self, name='scipy filter',
                                     in_sig=[np.float32], out_sig=[np.float32])
              self.taps = np.array([1, 2, 3, 4], dtype=np.float32) * gain
              self.set_history(len(self.taps))
              self.reported = False

          def work(self, input_items, output_items):  # taps sum to 10, input is 1.0
              n = len(output_items[0])
              output_items[0][:] = fftconvolve(input_items[0], self.taps, mode='valid')[:n]
              if not self.reported and n > 3:
                  self.reported = True
                  # The first three outputs still see the zeros GNU Radio pads the
                  # history with; the last output of a full block never does.
                  print('epy scipy steady output %.3f' % output_items[0][n - 1])
              return n
    gain: '1'
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_probe_signal_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
