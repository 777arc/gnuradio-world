options:
  parameters:
    id: wasm_qtgui_controls
    title: WASM QT GUI controls
  states: {}

blocks:
- name: tone
  id: variable_qtgui_numeric_entry
  parameters:
    label: Tone
    unit: Hz
    value: '1200'
    value_min: '0'
    value_max: '4000'
    increment: '100'
    precision: '10'
    description: ''
    enabled: 'True'
  states: {}
- name: readout
  id: variable_qtgui_label
  parameters:
    label: Tone now
    type: real
    value: tone
  states: {}
- name: gain_sw
  id: variable_qtgui_toggle_switch
  parameters:
    label: Gain
    type: real
    value: '2'
    initPressed: 'True'
    pressed: '2'
    released: '1'
    outputmsgname: gain
  states: {}
- name: level
  id: variable_qtgui_dial_control
  parameters:
    label: Level
    type: int
    value: '3'
    minimum: '0'
    maximum: '10'
    showvalue: 'True'
    outputmsgname: level
  states: {}
- name: mute
  id: variable_qtgui_msgcheckbox
  parameters:
    label: Mute
    type: int
    value: '0'
    initPressed: 'False'
    pressed: '1'
    released: '0'
    outputmsgname: mute
  states: {}
- name: burst
  id: variable_qtgui_toggle_button_msg
  parameters:
    label: Burst
    type: int
    value: '0'
    initPressed: 'False'
    pressed: '1'
    released: '0'
    outputmsgname: burst
    pressBackgroundColor: green
    pressFontColor: black
  states: {}
- name: ping
  id: variable_qtgui_msg_push_button
  parameters:
    label: Ping
    type: int
    msgName: ping
    value: '1'
  states: {}
- name: dial_freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Frequency
    minFreqHz: '0'
    maxFreqHz: '1000'
    value: '0'
  states: {}
- name: edit
  id: qtgui_edit_box_msg
  parameters:
    type: string
    value: hello
    label: Edit
    key: edit
  states: {}
- name: src
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: '32000'
    waveform: analog.GR_COS_WAVE
    frequency: tone
    amplitude: '1'
    offset: '0'
    phase: '0'
  states: {}
- name: amp
  id: blocks_multiply_const_xx
  parameters:
    type: complex
    constant: gain_sw
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: sink
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: freq_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern("freq"), pmt.from_double(42))
    period: '200'
  states: {}
- name: message_debug
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [src, '0', amp, '0']
- [amp, '0', throttle, '0']
- [throttle, '0', sink, '0']
- {src_blk_id: freq_strobe, src_port_id: strobe, snk_blk_id: dial_freq, snk_port_id: valuein}
- {src_blk_id: dial_freq, src_port_id: valueout, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: edit, src_port_id: msg, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: ping, src_port_id: pressed, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: burst, src_port_id: state, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: mute, src_port_id: state, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: gain_sw, src_port_id: state, snk_blk_id: message_debug, snk_port_id: print}
- {src_blk_id: level, src_port_id: value, snk_blk_id: message_debug, snk_port_id: print}

metadata:
  file_format: 2
  grc_version: 3.10.9.2
