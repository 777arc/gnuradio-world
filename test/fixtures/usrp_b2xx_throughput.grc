options:
  parameters:
    description: 'USRP B2xx throughput reference: source straight into a Null Sink, with no GUI block of any kind, so the browser main thread is idle while the radio streams. Run it beside b2xx_spectrum_analyzer.grc to separate what the transport can do from what is left after Qt has repainted the plots. The block reports its delivered rate about five seconds in.'
    generate_options: qt_gui
    id: usrp_b2xx_throughput
    title: USRP B2xx Throughput Reference
  states: {}

blocks:
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}
- name: wasm_usrp_b2xx_source_0
  id: wasm_usrp_b2xx_source
  parameters:
    antenna: RX2
    bandwidth: '0'
    center_freq: '100000000'
    device: ''
    gain: '30'
    master_clock_rate: '0'
    samp_rate: '1000000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [wasm_usrp_b2xx_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
