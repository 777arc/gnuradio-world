options:
  parameters:
    id: sdrplay_fake
  states: {}

blocks:
- name: rsp
  id: wasm_sdrplay_rsp1a_source
  parameters:
    device: fake:100000
    samp_rate: '2000000'
    center_freq: '100000000'
    bandwidth: '0'
    gain: '40'
    bias_tee: 'False'
    fm_notch: 'False'
    dab_notch: 'False'
    transfer_size: '16384'
  states: {}
- name: rx_null
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [rsp, '0', rx_null, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
