options:
  parameters:
    id: wasm_added_fec
    title: WASM added FEC blocks
  states: {}

blocks:
- name: source
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: '[0, 1, 1, 0, 1, 0, 0, 1]'
    repeat: 'True'
  states: {}
- name: source_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '16000'
    type: byte
  states: {}
- name: ccsds_encoder
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {}
- name: uchar_to_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: ccsds_decoder
  id: fec_decode_ccsds_27_fb
  parameters: {}
  states: {}
- name: ccsds_sink
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: puncture
  id: fec_puncture_xx
  parameters:
    type: byte
    puncsize: '4'
    puncpat: '13'
    delay: '0'
  states: {}
- name: depuncture
  id: fec_depuncture_bb
  parameters:
    puncsize: '4'
    puncpat: '13'
    delay: '0'
  states: {}
- name: puncture_sink
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: ber
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
    berlimit: '-7'
  states: {}
- name: ber_sink
  id: blocks_null_sink
  parameters:
    type: float
  states: {}

connections:
- [source, '0', source_throttle, '0']
- [source_throttle, '0', ccsds_encoder, '0']
- [ccsds_encoder, '0', uchar_to_float, '0']
- [uchar_to_float, '0', ccsds_decoder, '0']
- [ccsds_decoder, '0', ccsds_sink, '0']
- [source_throttle, '0', puncture, '0']
- [puncture, '0', depuncture, '0']
- [depuncture, '0', puncture_sink, '0']
- [source_throttle, '0', ber, '0']
- [source_throttle, '0', ber, '1']
- [ber, '0', ber_sink, '0']

metadata:
  file_format: 1
