options:
  parameters:
    id: audio_devices
    title: Audio Sink and Audio Source
  states: {}

blocks:
- name: tone
  id: analog_sig_source_x
  parameters:
    type: float
    samp_rate: '48000'
    waveform: analog.GR_COS_WAVE
    frequency: '440'
    amplitude: '0.2'
    offset: '0'
    phase: '0'
  states: {}
- name: speaker
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: microphone
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: level
  id: blocks_rms_xx
  parameters:
    type: float
    alpha: '0.0001'
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}

connections:
- [tone, '0', speaker, '0']
- [microphone, '0', level, '0']
- [level, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
