options:
  parameters:
    id: grwire_mock
  states: {}

blocks:
- name: src
  id: wasm_grwire_source
  parameters:
    server: ws://localhost:8101/grwire
    device: fake
    type: complex
    samp_rate: '1000000'
    center_freq: '100000000'
    offset: '0'
    decim: '1'
    gain_mode: 'False'
    gain: '30'
    stage1: '24'
    stage2: '-1000'
    stage3: '18'
    bandwidth: '0'
    wire_format: ci8
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}

connections:
- [src, '0', mag, '0']
- [mag, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
