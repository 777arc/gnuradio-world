options:
  parameters:
    id: sigmf_source_tags
  states: {}

blocks:
- name: source
  id: wasm_sigmf_source
  parameters:
    file: /local-files/sigmf-test/tagged.sigmf-data
    length: '0'
    offset: '2'
    repeat: 'False'
    tags: 'True'
    type: complex
    use_samp_rate: 'True'
  states: {}
- name: tags
  id: blocks_tag_debug
  parameters:
    name: sigmf
    type: complex
  states: {}

connections:
- [source, '0', tags, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
