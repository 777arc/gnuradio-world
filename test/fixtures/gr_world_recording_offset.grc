options:
  parameters:
    id: gr_world_recording_offset
  states: {}

blocks:
- name: source
  id: wasm_gr_world_recording
  parameters:
    length: '1'
    offset: '3'
    recording: fm_rds_250k_1Msamples
    repeat: 'False'
    type: complex
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}

connections:
- [source, '0', probe, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
