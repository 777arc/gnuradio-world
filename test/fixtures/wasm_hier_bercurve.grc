options:
  parameters:
    id: wasm_hier_bercurve
    title: WASM FEC BER curve generator
  states: {}

blocks:
- name: encoder_def
  id: variable_cc_encoder_def
  parameters:
    ndim: '1'
    dim1: '2'
    framebits: '512'
    k: '7'
    rate: '2'
    polys: '[79, 109]'
    state_start: '0'
    mode: fec.CC_TERMINATED
    padding: 'False'
  states: {}
- name: decoder_def
  id: variable_cc_decoder_def
  parameters:
    ndim: '1'
    dim1: '2'
    framebits: '512'
    k: '7'
    rate: '2'
    polys: '[79, 109]'
    state_start: '0'
    state_end: '-1'
    mode: fec.CC_TERMINATED
    padding: 'False'
  states: {}
- name: curve
  id: fec_bercurve_generator
  parameters:
    esno: '[-4.0, 12.0]'
    samp_rate: '200000'
    encoder_list: encoder_def
    decoder_list: decoder_def
    puncpat: '11'
    threadtype: none
  states: {}
- name: bercurve
  id: qtgui_bercurve_sink
  parameters:
    esno: '[-4.0, 12.0]'
    berminerrors: '100'
    berlimit: '-4.0'
  states: {}

connections:
- [curve, '0', bercurve, '0']
- [curve, '1', bercurve, '1']
- [curve, '2', bercurve, '2']
- [curve, '3', bercurve, '3']

metadata:
  file_format: 1
