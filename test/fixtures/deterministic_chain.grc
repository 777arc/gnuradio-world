options:
  parameters:
    id: deterministic_chain
    title: Deterministic scheduler repeatability
    scheduler: det
  states: {}

blocks:
- name: src
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    mode: scalar
    const: '2'
  states: {}
- name: shift
  id: blocks_delay
  parameters:
    type: complex
    delay: '17'
  states: {}
- name: snk
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [src, '0', scale, '0']
- [scale, '0', shift, '0']
- [shift, '0', snk, '0']

metadata:
  file_format: 1
