blocks:
- name: source
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95]'
    repeat: 'False'
  states: {}
- name: tagger
  id: blocks_stream_to_tagged_stream
  parameters:
    type: byte
    packet_len: '96'
    len_tag_key: length
  states: {}
- name: transmitter
  id: digital_ofdm_tx
  parameters:
    fft_len: '64'
    cp_len: '16'
    packet_len_key: length
    header_mod: '"BPSK"'
    payload_mod: '"BPSK"'
    rolloff: '0'
  states: {}
- name: receiver
  id: digital_ofdm_rx
  parameters:
    fft_len: '64'
    cp_len: '16'
    packet_len_key: '"length"'
    header_mod: '"BPSK"'
    payload_mod: '"BPSK"'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: '192000'
    type: complex
  states: {}
- name: tag_gate
  id: blocks_tag_gate
  parameters:
    type: complex
    propagate_tags: 'False'
  states: {}
- name: delay
  id: blocks_delay
  parameters:
    type: complex
    delay: '100'
  states: {}
- name: zero_tail
  id: analog_const_source_x
  parameters:
    type: complex
    const: '0'
  states: {}
- name: burst_mux
  id: blocks_stream_mux
  parameters:
    type: complex
    lengths: (1700, 1000)
  states: {}
- name: sink
  id: blocks_file_sink
  parameters:
    file: '"/ofdm_rx_output.bin"'
    type: byte
    unbuffered: 'True'
  states: {}

connections:
- [source, '0', tagger, '0']
- [tagger, '0', transmitter, '0']
- [transmitter, '0', delay, '0']
- [delay, '0', burst_mux, '0']
- [zero_tail, '0', burst_mux, '1']
- [burst_mux, '0', throttle, '0']
- [throttle, '0', tag_gate, '0']
- [tag_gate, '0', receiver, '0']
- [receiver, '0', sink, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
